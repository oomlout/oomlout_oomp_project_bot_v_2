# Repository oomlout/oomlout_oomp_project_bot_v_2

## KiCad design projects/fatenozomi_shichi_pcb_shichi_pcb/current_version/working/working.kicad_pcb

File projects/fatenozomi_shichi_pcb_shichi_pcb/current_version/working/readme.md:

# shichi_pcb
 
## summary 
* id: fatenozomi_shichi_pcb_shichi_pcb
* user: fatenozomi
* name: shichi_pcb
* board: shichi_pcb
* repo: https://github.com/FateNozomi/shichi-pcb
* src_file_repo_kicad_pcb: shichi-pcb.kicad_pcb
* src_file_repo_kicad_pcb_link: https://github.com/FateNozomi/shichi-pcb/tree/master/shichi-pcb.kicad_pcb

* src_file_repo_sch: 
* src_file_repo_sch_link: https://github.com/FateNozomi/shichi-pcb/tree/master/
* full details link: https://github.com/oomlout/oomlout_oomp_project_bot_v_2/tree/main/projects/fatenozomi_shichi_pcb_shichi_pcb/current_version/working

Board: 2 copper layers, 266.0 x 96.0 mm, 169 parts (97 on the bottom side), 111 nets.

Parts:
C1, C2: 22pF; C_0805_2012Metric_Pad1.15x1.40mm_HandSolder
C3: 10uF; C_0805_2012Metric_Pad1.15x1.40mm_HandSolder
C4, C5: 1uF; C_0805_2012Metric_Pad1.15x1.40mm_HandSolder
C6, C7, C8, C9: 0.1uF; C_0805_2012Metric_Pad1.15x1.40mm_HandSolder
D1, D2, D3, D4, D5, D6, D7, D8, D9, D10, D11, D12, D13, D14, D15, D16, D17, D18, D19, D20, D21, D22, D23, D24, D25, D26, D27, D28, D29, D30, D31, D32, D33, D34, D35, D36, D37, D38, D39, D40, D41, D42, D43, D44, D45, D46, D47, D48, D49, D50, D51, D52, D53, D54, D55, D56, D57, D58, D59, D60, D61, D62, D63, D64, D65, D66, D67, D68, D69, D70: D; D_SOD-123
F1: Polyfuse; Fuse_1206_3216Metric_Pad1.42x1.75mm_HandSolder
J1: USB_C_Receptacle_HRO_TYPE-C-31-M-12; USB_C_Receptacle_HRO_TYPE-C-31-M-12-HandSoldering
J2, J4: Conn_01x04_Male; PinHeader_1x04_P2.54mm_Vertical
J3: Conn_01x06_Male; PinHeader_1x06_P2.54mm_Vertical
J5, J6, J7: Conn_01x01_Male; PinHeader_1x01_P2.54mm_Vertical
K1, K2, K3, K4, K5, K6, K7, K8, K9, K10, K11, K12, K13, K14, K15, K16, K17, K18, K19, K20, K21, K22, K23, K24, K25, K26, K27, K28, K29, K30, K31, K32, K33, K34, K35, K36, K37, K38, K39, K40, K41, K42, K43, K44, K45, K46, K47, K48, K49, K50, K51, K52, K53, K54, K55, K56, K57, K58, K59, K60, K61, K62, K63, K64, K65, K66, K67, K68, K69, K70: SW_Push; SW_Cherry_MX_1.00u_PCB_Socket
K71, K72: SW_Push; SW_Cherry_MX_2.00u_PCB_Socket
R1, R2: 5.1k; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
R3, R4: 22; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
R5, R6: 10k; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
SW1: SW_Push; SW_SPST_TL3342
U1: USBLC6-2SC6; SOT-23-6
U2: ATmega32U4-AU; TQFP-44_10x10mm_P0.8mm
Y1: Crystal_GND24; Crystal_SMD_SeikoEpson_FA238-4Pin_3.2x2.5mm_HandSoldering

Connections:
+5V: C3.1, C5.1, C6.1, C7.1, C8.1, C9.1, F1.1, J3.2, J4.3, R5.1, U2.2, U2.7, U2.14, U2.24, U2.34, U2.44
/MISO: J3.1, U2.11
/MOSI: J3.4, K7.1, K21.1, K35.1, K49.1, K63.1, U2.10
/SCK: J3.3, K6.1, K20.1, K34.1, K48.1, K62.1, K71.1, U2.9
/col0: K1.1, K15.1, K29.1, K43.1, K57.1, U2.40
/col1: K2.1, K16.1, K30.1, K44.1, K58.1, U2.39
/col2: K3.1, K17.1, K31.1, K45.1, K59.1, U2.38
/col3: K4.1, K18.1, K32.1, K46.1, K60.1, U2.37
/col4: K5.1, K19.1, K33.1, K47.1, K61.1, U2.8
/col7: K8.1, K22.1, K36.1, K50.1, K64.1, U2.36
/col8: K9.1, K23.1, K37.1, K51.1, K65.1, K72.1, U2.30
/col9: K10.1, K24.1, K38.1, K52.1, K66.1, U2.29
/col10: K11.1, K25.1, K39.1, K53.1, K67.1, U2.28
/col11: K12.1, K26.1, K40.1, K54.1, K68.1, U2.27
/col12: K13.1, K27.1, K41.1, K55.1, K69.1, U2.26
/col13: K14.1, K28.1, K42.1, K56.1, K70.1, U2.25
/row0: D1.1, D2.1, D3.1, D4.1, D5.1, D6.1, D7.1, D8.1, D9.1, D10.1, D11.1, D12.1, D13.1, D14.1, U2.20
/row1: D15.1, D16.1, D17.1, D18.1, D19.1, D20.1, D21.1, D22.1, D23.1, D24.1, D25.1, D26.1, D27.1, D28.1, U2.21
/row2: D29.1, D30.1, D31.1, D32.1, D33.1, D34.1, D35.1, D36.1, D37.1, D38.1, D39.1, D40.1, D41.1, D42.1, U2.22
/row3: D43.1, D44.1, D45.1, D46.1, D47.1, D48.1, D49.1, D50.1, D51.1, D52.1, D53.1, D54.1, D55.1, D56.1, U2.41
/row4: D57.1, D58.1, D59.1, D60.1, D61.1, D62.1, D63.1, D64.1, D65.1, D66.1, D67.1, D68.1, D69.1, D70.1, U2.32
B7: J5.1, U2.12
C6: J6.1, U2.31
D+: R4.2, U2.4
D+Bus: J1.A6, J1.B6, J2.3, U1.6
D-: R3.2, U2.3
D-Bus: J1.A7, J1.B7, J2.2, U1.4
E6: J7.1, U2.1
GND: C1.1, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, J1.A1, J1.A12, J1.S1, J2.4, J3.6, J4.4, R1.1, R2.2, R6.1, SW1.1, U1.2, U2.5, U2.15, U2.23, U2.35, U2.43, Y1.2, Y1.4
unnamed: C4.1, U2.6
unnamed: D1.2, K1.2
unnamed: D2.2, K2.2
unnamed: D3.2, K3.2
unnamed: D4.2, K4.2
unnamed: D5.2, K5.2
unnamed: D6.2, K6.2
unnamed: D7.2, K7.2
unnamed: D8.2, K8.2
unnamed: D9.2, K9.2
unnamed: D10.2, K10.2
unnamed: D11.2, K11.2
unnamed: D12.2, K12.2
unnamed: D13.2, K13.2
unnamed: D14.2, K14.2
unnamed: D15.2, K15.2
unnamed: D16.2, K16.2
unnamed: D17.2, K17.2
unnamed: D18.2, K18.2
unnamed: D19.2, K19.2
unnamed: D20.2, K20.2
unnamed: D21.2, K21.2
unnamed: D22.2, K22.2
unnamed: D23.2, K23.2
unnamed: D24.2, K24.2
unnamed: D25.2, K25.2
unnamed: D26.2, K26.2
unnamed: D27.2, K27.2
unnamed: D28.2, K28.2
unnamed: D29.2, K29.2
unnamed: D30.2, K30.2
unnamed: D31.2, K31.2
unnamed: D32.2, K32.2
unnamed: D33.2, K33.2
unnamed: D34.2, K34.2
unnamed: D35.2, K35.2
unnamed: D36.2, K36.2
unnamed: D37.2, K37.2
unnamed: D38.2, K38.2
unnamed: D39.2, K39.2
unnamed: D40.2, K40.2
unnamed: D41.2, K41.2
unnamed: D42.2, K42.2
unnamed: D43.2, K43.2
unnamed: D44.2, K44.2
unnamed: D45.2, K45.2
unnamed: D46.2, K46.2
unnamed: D47.2, K47.2
unnamed: D48.2, K48.2
unnamed: D49.2, K49.2
unnamed: D50.2, K50.2
unnamed: D51.2, K51.2
unnamed: D52.2, K52.2
unnamed: D53.2, K53.2
unnamed: D54.2, K54.2
unnamed: D55.2, K55.2
unnamed: D56.2, K56.2
unnamed: D57.2, K57.2
unnamed: D58.2, K58.2
unnamed: D59.2, K59.2
unnamed: D60.2, K60.2
unnamed: D61.2, K61.2
unnamed: D62.2, K62.2, K71.2
unnamed: D63.2, K63.2
unnamed: D64.2, K64.2
unnamed: D65.2, K65.2, K72.2
unnamed: D66.2, K66.2
unnamed: D67.2, K67.2
unnamed: D68.2, K68.2
unnamed: D69.2, K69.2
unnamed: D70.2, K70.2
unnamed: J1.A5, R1.2
unnamed: J1.B5, R2.1
unnamed: R3.1, U1.3
unnamed: R4.1, U1.1
unnamed: R6.2, U2.33
RESET: J3.5, R5.2, SW1.2, U2.13
SCL: J4.1, U2.18
SDA: J4.2, U2.19
VCC: F1.2, J1.A4, J1.A9, J2.1, U1.5
XTAL1: C1.2, U2.17, Y1.1
XTAL2: C2.1, U2.16, Y1.3

## KiCad design projects/freetronics_cube4_hardware_cube4_matrix_plane/current_version/working/working.kicad_pcb

File projects/freetronics_cube4_hardware_cube4_matrix_plane/current_version/working/readme.md:

# cube4_hardware
 
## summary 
* id: freetronics_cube4_hardware_cube4_matrix_plane
* user: freetronics
* name: cube4_hardware
* board: cube4_matrix_plane
* repo: https://github.com/freetronics/Cube4-hardware
* src_file_repo_kicad_pcb: cube4-matrix-plane/cube4-matrix-plane.kicad_pcb
* src_file_repo_kicad_pcb_link: https://github.com/freetronics/Cube4-hardware/tree/master/cube4-matrix-plane/cube4-matrix-plane.kicad_pcb

* src_file_repo_sch: cube4-matrix-plane/cube4-matrix-plane.sch
* src_file_repo_sch_link: https://github.com/freetronics/Cube4-hardware/tree/master/cube4-matrix-plane/cube4-matrix-plane.sch
* full details link: https://github.com/oomlout/oomlout_oomp_project_bot_v_2/tree/main/projects/freetronics_cube4_hardware_cube4_matrix_plane/current_version/working

Parts:
LED1, LED2, LED3, LED4, LED5, LED6, LED7, LED8, LED9, LED10, LED11, LED12, LED13, LED14, LED15, LED16: LED_RGB_COM_K; LED_RGB_8MM_COM_K
P1: Y3; LED_MATRIX_PLANE_4PAD
P5: Y2; LED_MATRIX_PLANE_4PAD
P9: Y1; LED_MATRIX_PLANE_4PAD
P13: Y0; LED_MATRIX_PLANE_4PAD
P17, P21, P25, P29: Z; LED_MATRIX_PLANE_4PAD

Connections:
/X0Y0: LED1.K, P13.1
/X0Y1: LED5.K, P9.1
/X0Y2: LED9.K, P5.1
/X0Y3: LED13.K, P1.1
/X1Y0: LED2.K, P13.2
/X1Y1: LED6.K, P9.2
/X1Y2: LED10.K, P5.2
/X1Y3: LED14.K, P1.2
/X2Y0: LED3.K, P13.3
/X2Y1: LED7.K, P9.3
/X2Y2: LED11.K, P5.3
/X2Y3: LED15.K, P1.3
/X3Y0: LED4.K, P13.4
/X3Y1: LED8.K, P9.4
/X3Y2: LED12.K, P5.4
/X3Y3: LED16.K, P1.4
/Z_BLUE: LED1.AB, LED2.AB, LED3.AB, LED4.AB, LED5.AB, LED6.AB, LED7.AB, LED8.AB, LED9.AB, LED10.AB, LED11.AB, LED12.AB, LED13.AB, LED14.AB, LED15.AB, LED16.AB, P17.3, P21.3, P25.3, P29.3
/Z_GREEN: LED1.AG, LED2.AG, LED3.AG, LED4.AG, LED5.AG, LED6.AG, LED7.AG, LED8.AG, LED9.AG, LED10.AG, LED11.AG, LED12.AG, LED13.AG, LED14.AG, LED15.AG, LED16.AG, P17.2, P21.2, P25.2, P29.2
/Z_RED: LED1.AR, LED2.AR, LED3.AR, LED4.AR, LED5.AR, LED6.AR, LED7.AR, LED8.AR, LED9.AR, LED10.AR, LED11.AR, LED12.AR, LED13.AR, LED14.AR, LED15.AR, LED16.AR, P17.1, P21.1, P25.1, P29.1

Notes on the sheet:
0,0,2
0,0,0 X,Y,Z
Qty: 4 pieces of this matrix plane pcb per cube (Z0, Z1, Z2, Z3)
1,0,0
0,1,0
Freetronics ColourCube
plane
0,2,0
www.freetronics.com/cube
0,0,3
Marc Alexander
2,0,0
matrix
0,0,1
0,3,0
3,0,0

Board: 2 copper layers, 92.0 x 79.6 mm, 24 parts (0 on the bottom side), 19 nets.

## KiCad design projects/freetronics_cube4_hardware_cube4_matrix_sticks/current_version/working/working.kicad_pcb

File projects/freetronics_cube4_hardware_cube4_matrix_sticks/current_version/working/readme.md:

# cube4_hardware
 
## summary 
* id: freetronics_cube4_hardware_cube4_matrix_sticks
* user: freetronics
* name: cube4_hardware
* board: cube4_matrix_sticks
* repo: https://github.com/freetronics/Cube4-hardware
* src_file_repo_kicad_pcb: cube4-matrix-sticks/cube4-matrix-sticks.kicad_pcb
* src_file_repo_kicad_pcb_link: https://github.com/freetronics/Cube4-hardware/tree/master/cube4-matrix-sticks/cube4-matrix-sticks.kicad_pcb

* src_file_repo_sch: cube4-matrix-sticks/cube4-matrix-sticks.sch
* src_file_repo_sch_link: https://github.com/freetronics/Cube4-hardware/tree/master/cube4-matrix-sticks/cube4-matrix-sticks.sch
* full details link: https://github.com/oomlout/oomlout_oomp_project_bot_v_2/tree/main/projects/freetronics_cube4_hardware_cube4_matrix_sticks/current_version/working

Parts:
JP6: Y3; LED_STICK_BASE_4PAD
JP7: Y2; LED_STICK_BASE_4PAD
JP8: Y1; LED_STICK_BASE_4PAD
JP9: Y0; LED_STICK_BASE_4PAD
JP11: Z3; LED_STICK_BASE_4PAD
JP12: Z2; LED_STICK_BASE_4PAD
JP13: Z1; LED_STICK_BASE_4PAD
JP14: Z0; LED_STICK_BASE_4PAD
P1, P5, P9, P13, P17, P21, P25, P29: Z3; LED_MATRIX_VERTICAL_4PAD
P2, P6, P10, P14, P18, P22, P26, P30: Z2; LED_MATRIX_VERTICAL_4PAD
P3, P7, P11, P15, P19, P23, P27, P31: Z1; LED_MATRIX_VERTICAL_4PAD
P4, P8, P12, P16, P20, P24, P28, P32: Z0; LED_MATRIX_VERTICAL_4PAD

Connections:
/X0Y0: JP9.1, P13.1, P14.1, P15.1, P16.1
/X0Y1: JP8.1, P9.1, P10.1, P11.1, P12.1
/X0Y2: JP7.1, P5.1, P6.1, P7.1, P8.1
/X0Y3: JP6.1, P1.1, P2.1, P3.1, P4.1
/X1Y0: JP9.2, P13.2, P14.2, P15.2, P16.2
/X1Y1: JP8.2, P9.2, P10.2, P11.2, P12.2
/X1Y2: JP7.2, P5.2, P6.2, P7.2, P8.2
/X1Y3: JP6.2, P1.2, P2.2, P3.2, P4.2
/X2Y0: JP9.3, P13.3, P14.3, P15.3, P16.3
/X2Y1: JP8.3, P9.3, P10.3, P11.3, P12.3
/X2Y2: JP7.3, P5.3, P6.3, P7.3, P8.3
/X2Y3: JP6.3, P1.3, P2.3, P3.3, P4.3
/X3Y0: JP9.4, P13.4, P14.4, P15.4, P16.4
/X3Y1: JP8.4, P9.4, P10.4, P11.4, P12.4
/X3Y2: JP7.4, P5.4, P6.4, P7.4, P8.4
/X3Y3: JP6.4, P1.4, P2.4, P3.4, P4.4
/Z0_BLUE: JP14.3, P32.3
/Z0_GREEN: JP14.2, P32.2
/Z0_RED: JP14.1, P32.1
/Z1_BLUE: JP13.3, P27.3
/Z1_GREEN: JP13.2, P27.2
/Z1_RED: JP13.1, P27.1
/Z2_BLUE: JP12.3, P22.3
/Z2_GREEN: JP12.2, P22.2
/Z2_RED: JP12.1, P22.1
/Z3_BLUE: JP11.3, P17.3
/Z3_GREEN: JP11.2, P17.2
/Z3_RED: JP11.1, P17.1

Notes on the sheet:
3,0,0
X0-3 Cathodes
0,1,0
0,0,3
www.freetronics.com/cube
0,2,0
matrix
Freetronics ColourCube
Z2 RGB Anodes
LED Matrix Connections (base of matrix)
0,0,1
Z0 RGB Anodes
0,0,0 X,Y,Z
0,3,0
2,0,0
Z1 RGB Anodes
1,0,0
Marc Alexander
sticks
Z3 RGB Anodes
0,0,0
0,0,2

Board: 2 copper layers, 94.0 x 96.0 mm, 40 parts (0 on the bottom side), 28 nets.

Notices in the files:
projects/freetronics_etherdue_etherdue/current_version/working/working.kicad_pcb:
Under Creative Commons Attribution ShareAlike License
Licensed by Freetronics Pty Ltd
projects/freetronics_oled128_oled128/current_version/working/working.kicad_pcb:
(c) 2013 Freetronics Pty Ltd / TAPR OH License
