# Repository oomlout/oomlout_oomp_project_bot_v_2 (continued)

## KiCad design projects/freetronics_etherdue_etherdue/current_version/working/working.kicad_pcb

File projects/freetronics_etherdue_etherdue/current_version/working/readme.md:

# etherdue
 
## summary 
* id: freetronics_etherdue_etherdue
* user: freetronics
* name: etherdue
* board: etherdue
* repo: https://github.com/freetronics/EtherDue
* src_file_repo_kicad_pcb: EtherDue.kicad_pcb
* src_file_repo_kicad_pcb_link: https://github.com/freetronics/EtherDue/tree/master/EtherDue.kicad_pcb

* src_file_repo_sch: EtherDue.sch
* src_file_repo_sch_link: https://github.com/freetronics/EtherDue/tree/master/EtherDue.sch
* full details link: https://github.com/oomlout/oomlout_oomp_project_bot_v_2/tree/main/projects/freetronics_etherdue_etherdue/current_version/working

Board: 4 copper layers, 101.6 x 53.3 mm, 158 parts (10 on the bottom side), 179 nets.

Parts:
C201, C202, C205, C303, C304, C601, C602: 22pF; SM0402
C203, C204: 22pF_NM; SM0402
C206, C207, C208, C301, C302, C503, C504, C509, C511, C512, C513, C514, C515, C516, C520, C521, C522, C523, C524, C526, C527, C603, C605, C607, C609, C610, C611, C701: 100nF; SM0402
C305: 1uF; SM0402
C401, C505: 10nF; SM0402
C402, C403, C506, C507, C517, C518, C519, C528: 10uF; SM0603_Capa
C501: 47uF 25V; c_elec_5x5.3
C502: 10uF 25V; SM1206
C510: 100uF 16V; c_elec_5x5.3
C604, C606, C608: 10uF 6.3V A TANT; SM1206POL
D201, D202, D204, D302, D303, D601, D605, D606: YELLOW; LED-0603
D203, D602, D603: GREEN; LED-0603
D301: CD1206-S; 1206_DIODE
D501: 1N4004; SMB-DIODE
D502: CD1206-S01575; 1206_DIODE
D503: SK34A-LTP; SMA-DIODE
D604: RED; LED-0603
DEBUG401: M04; PIN_ARRAY_4x1
F301, F401: 500mA PTC 1812; SM1812
FIDUCIAL: val**; FIDUCIAL
FIDUCIAL#2: val**; FIDUCIAL
IC201: ATSAM3X8E; TQFP144
IC301: ATMEGA16U2; QFN32
IC601: W5100; SQFP80
ICSP301: M02X03; pin_array_3x2
JP401: JTAG; 2X5_127MMPITCH
JP601: M04; FT-POE-MODULE-NOOUTLINE
L201, L501, L503, L504, L505: MH2029-300Y; MH2029
L502: 10uH SRR0604-100ML; SRR0604
L601, L602: 1uH 250mA; 0805
LOGO_CC: VAL**; LOGO_CC
LOGO_FREETRONICS: val**; LOGO_FREETRONICS
LOGO_FREETRONICS_SMALL: val**; LOGO_FREETRONICS_SMALL
P301, P401: USB_5PIN_SHELL; USB-MICRO_TH_4PEGS
Q501: BC847BSMD; SOT23_TRANSISTOR
Q601: 2N7002; SOT23
R201: 6k8 1%; SM0402_r
R202, R203: 39R 1%; SM0402_r
R204: 100K; SM0402_r
R205, R207, R304: 1K5; SM0402_r
R206, R601, R604: 1K; RES_CAY16
R208: 10K; SMD-0402_r
R301, R302: 22R; SM0402_r
R303, R310, R403, R503, R505: 10K; SM0402_r
R305: 2K7; SM0402_r
R306, R307, R308, R309, R501, R606, R607: 1K; SM0402_r
R401, R502: 100K; RES_CAY16
R504: 52K3; SM0402_r
R602: 1M; SM0402_r
R603: 12K3 1%; SM0402_r
R605: 49R9 1%; RES_CAY16
SHIELD401: ARDUINO_DUE_SHIELD
SJ201, SJ203, SJ601: OPEN; SJ_OPEN
SJ202, SJ401: CLOSED; SJ_SHORTED
SJ701, SJ702: SJ; SJ_SHORTED
SW201: ERASE; TACTILE_SWITCH_SMD_2PIN_TINY
SW202: RESET; TACTILE_SWITCH_SMD_2PIN_TINY
U202, U503, U504: FDN340P; SOT23_MOSFET
U203: LMV358IPWR; TSSOP8
U501: POWERJACK; POWER_JACK_PTH
U502: LM2734Y; SOT23-6
U505: NCP1117ST33T3G; SOT223
U602: HY931147C
U603: APX811-31UG-7; SOT143-R
U701: MICROSD; MICRO-SD-SOCKET-PP
U702: 24AA025E48; SOT23-6
VR401, VR402, VR403: PGB1010603; 0603
X201: TXC 7A 12MHz 18pF; TXC_7A
X202: ABS07L 32.768kHz; ABS07L
X301: TXC 7A 16MHz 18pF; TXC_7A
X601: TXC 7A 25MHz 18pF; TXC_7A
Z301, Z302: PGB1010603; 0603

Connections:
+3.3V: C208.1, C506.1, C515.1, C520.1, C522.1, C524.1, C526.1, C527.1, C528.1, C603.1, C701.1, D601.A, D602.A, D603.A, D604.A, D605.A, D606.A, IC201.11, IC201.52, IC201.57, IC201.62, IC201.105, IC201.125, IC601.12, IC601.18, IC601.44, JP401.1, L503.1, L504.1, L602.1, R204.1, R205.1, R206.3, R206.5, R206.7, R207.1, R208.1, R401.2, R401.4, R401.6, R401.8, R601.2, R601.4, SHIELD401.3V3, SHIELD401.IO_R, SJ202.1, SW201.2, U202.S, U203.6, U505.2, U602.11, U602.13, U603.4, U701.4
+5V: C302.1, C504.1, C510.1, D301.K, D502.A, IC301.4, IC301.32, ICSP301.2, L502.2, R303.1, R308.2, R309.2, R504.1, SHIELD401.5V, SHIELD401.5V_4, SHIELD401.5V_5, SHIELD401.SP2, U203.8, U503.S, U504.S, U505.3, U702.6
/Connectors//MASTER-RESET: C208.2, DEBUG401.4, IC201.47, R306.2, SHIELD401.RST, SHIELD401.SP5, SJ401.2, SW202.1, U603.3
/Connectors/D+: IC201.37, P401.3, R203.1, VR402.1
/Connectors/D-: IC201.38, P401.2, R202.1, VR401.1
/Connectors/RX: IC201.27, R304.2, R305.1, SHIELD401.0
/Connectors/TX: IC201.2, IC301.8, SHIELD401.1
/Connectors/UOTGID: IC201.129, P401.4, VR403.1
/Connectors/USBVCC: C402.1, C403.1, F401.2, R307.2, R403.1, U503.D
/Connectors/XUSB: C401.2, F401.1, IC201.39, P401.1
/Ethernet/1V8A: C606.1, IC601.7, IC601.74, L601.2
/Ethernet/1V8D: C604.1, C605.1, C607.1, IC601.11, IC601.15, IC601.16, IC601.33, IC601.69, L601.1
/Ethernet/3V3A: C608.1, C611.1, IC601.2, L602.2, U602.3, U602.4
/Ethernet/COLLED: IC601.71, R604.5
/Ethernet/FDXLED: IC601.70, R604.7, R607.1
/Ethernet/LINKLED: IC601.66, R601.7, R606.1
/Ethernet/POE_V+: JP601.3, U602.9
/Ethernet/POE_V-: JP601.2, U602.10
/Ethernet/RXLED: IC601.72, R604.3
/Ethernet/SPDLED: IC601.67, R601.5
/Ethernet/TXLED: IC601.73, R604.1
/Ethernet/WIZRST: IC601.59, U603.2
/MCU//ERASE_CMD: IC301.23, R208.2, U202.G
/MCU/ERASE: IC201.130, SW201.1, U202.D
/MCU/LED_ON: R206.1, U203.1, U203.2
/MCU/RXL: D202.K, IC201.103
/MCU/TXL: D201.K, IC201.107
/MCU/UOTGVBOF: IC201.128, R501.1
/MCU/VDDANA: C512.1, C517.1, IC201.73, L503.2
/MCU/VDDOUT: C507.1, C509.1, C511.1, C516.1, C521.1, C523.1, IC201.10, IC201.45, IC201.56, IC201.61, IC201.104, IC201.124, L505.1
/MCU/VDDOUTMI: C513.1, C518.1, IC201.41, L504.2
/MCU/VDDPLL: C514.1, C519.1, IC201.34, L505.2
/Mega16U2/16U2_TX: IC301.9, R304.1
/Mega16U2/MISO: IC301.17, ICSP301.1
/Mega16U2/MOSI: IC301.16, ICSP301.4
/Mega16U2/RD+: IC301.29, R302.2
/Mega16U2/RD+_CONN: P301.3, R302.1, Z302.2
/Mega16U2/RD-: IC301.30, R301.2
/Mega16U2/RD-_CONN: P301.2, R301.1, Z301.2
/Mega16U2/RESET: D301.A, IC301.24, ICSP301.5, R303.2
/Mega16U2/RESET_CMD: IC301.22, R306.1
/Mega16U2/RXL: D303.K, IC301.10
/Mega16U2/SCK: IC301.15, ICSP301.3
/Mega16U2/TXL: D302.K, IC301.11
/Mega16U2/USB Boot Enable: IC301.13, R310.1
/Mega16U2/USBVCCU2: C301.1, F301.2, IC301.31, U504.D
/Mega16U2/USBVCCU2_CONN: F301.1, P301.1
/Mega16U2/XTAL1: C304.2, IC301.1, X301.1
/Mega16U2/XTAL2: C303.2, IC301.2, X301.2
/Power/BUCK_FB: R504.2, R505.1, U502.3
/Power/BUCK_OUT: C505.1, D502.K, U502.1
/Power/BUCK_SW: C505.2, D503.K, L502.1, U502.6
/Power/CMP: C503.1, Q501.C, R502.5, R502.8, U203.5
/Power/GATE_CMD: U203.7, U503.G
/Power/POWER_JACK: D501.K, L501.1, U501.2
AD0: IC201.78, SHIELD401.AD0
AD1: IC201.79, SHIELD401.AD1
AD2: IC201.80, SHIELD401.AD2
AD3: IC201.81, SHIELD401.AD3
AD4: IC201.82, SHIELD401.AD4
AD5: IC201.83, SHIELD401.AD5
AD6: IC201.84, SHIELD401.AD6
AD7: IC201.85, SHIELD401.AD7
AD8: IC201.88, SHIELD401.AD8
AD9: IC201.89, SHIELD401.AD9
AD10: IC201.90, SHIELD401.AD10
AD11/TXD3: IC201.91, SHIELD401.AD11
AD14/RXD3: IC201.92, SHIELD401.52
AREF: SHIELD401.AREF, SJ203.1
CANRX0: IC201.24, SHIELD401.C_RX
CANTX0: IC201.23, SHIELD401.C_TX
CANTX1/IO: IC201.140, SHIELD401.53
DAC0/CANRX1: IC201.76, SHIELD401.DAC0
DAC1: IC201.77, SHIELD401.DAC1
GND: C201.1, C202.1, C203.1, C204.1, C205.2, C206.2, C207.2, C301.2, C302.2, C303.1, C304.1, C305.2, C401.1, C402.2, C403.2, C501.2, C502.2, C503.2, C504.2, C506.2, C507.2, C509.2, C510.2, C511.2, C512.2, C513.2, C514.2, C515.2, C516.2, C517.2, C518.2, C519.2, C520.2, C521.2, C522.2, C523.2, C524.2, C526.2, C527.2, C528.2, C601.2, C602.2, C603.2, C604.2, C605.2, C606.2, C607.2, C608.2, C609.2, C610.2, C611.2, C701.2, D203.K, D204.K, D501.A, D503.A, DEBUG401.1, IC201.12, IC201.33, IC201.44, IC201.46, IC201.54, IC201.58, IC201.74, IC201.106, IC201.126, IC301.3, IC301.28, IC301.PAD, IC601.4, IC601.10, IC601.13, IC601.14, IC601.17, IC601.19, IC601.20, IC601.21, IC601.22, IC601.23, IC601.24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
JTAG_RESET: JP401.10, R401.7, SJ401.1
JTAG_TCK: DEBUG401.2, IC201.28, JP401.4, R401.3
JTAG_TDI: IC201.29, JP401.8, R401.5
JTAG_TDO: IC201.30, JP401.6
JTAG_TMS: DEBUG401.3, IC201.31, JP401.2, R401.1
MISO: IC201.108, IC601.27, SHIELD401.SP1, U701.7
MOSI: IC201.109, IC601.28, SHIELD401.SP4, U701.3
unnamed: C201.2, IC201.35, X201.1
unnamed: C202.2, IC201.36, X201.2
unnamed: C203.2, IC201.49, X202.1
unnamed: C204.2, IC201.48, X202.2
unnamed: C205.1, IC201.40, R201.1
unnamed: C206.1, L201.1, SJ202.2, SJ203.2
unnamed: C207.1, IC201.75, L201.2
unnamed: C305.1, IC301.27
unnamed: C601.1, IC601.75, R602.2, X601.1
unnamed: C602.1, IC601.76, R602.1, X601.2
unnamed: C609.1, R605.1, R605.3
unnamed: C610.1, R605.5, R605.7
unnamed: D201.A, R206.8
unnamed: D202.A, R206.6
unnamed: D203.A, R206.4
unnamed: D204.A, R206.2
unnamed: D302.A, R308.1
unnamed: D303.A, R309.1
unnamed: D601.K, R601.8
unnamed: D602.K, R601.6
unnamed: D603.K, R604.8
unnamed: D604.K, R604.6
unnamed: D605.K, R604.4
unnamed: D606.K, R604.2
unnamed: IC201.42, R203.2
unnamed: IC201.43, R202.2
unnamed: IC201.51, SJ201.2
unnamed: IC201.53, R204.2
unnamed: IC301.26, R307.1
unnamed: IC601.1, R603.1
unnamed: IC601.5, R605.8, U602.1
unnamed: IC601.6, R605.6, U602.2
unnamed: IC601.8, R605.2, U602.5
unnamed: IC601.9, R605.4, U602.6
unnamed: IC601.31, Q601.3, R601.1
unnamed: IC601.55, IC601.57, IC601.58, R601.3
unnamed: IC601.56, SJ601.2
unnamed: Q501.B, R501.2, R502.4
unnamed: R503.2, U502.4
unnamed: R606.2, U602.12
unnamed: R607.2, U602.14
unnamed: SJ701.2, U702.1
unnamed: SJ702.2, U702.3
PIN22: IC201.1, SHIELD401.22
PIN23: IC201.7, SHIELD401.23
PIN24: IC201.8, SHIELD401.24
PIN25: IC201.13, SHIELD401.25
PIN26: IC201.14, SHIELD401.26
PIN27: IC201.15, SHIELD401.27
PIN28: IC201.16, SHIELD401.28
PIN29: IC201.19, SHIELD401.29
PIN30: IC201.22, SHIELD401.30
PIN31: IC201.26, SHIELD401.31
PIN32: IC201.32, SHIELD401.32
PIN33: IC201.55, SHIELD401.33
PIN34: IC201.59, SHIELD401.34
PIN35: IC201.60, SHIELD401.35
PIN36: IC201.116, SHIELD401.36
PIN37: IC201.63, SHIELD401.37
PIN38: IC201.64, SHIELD401.38
PIN39: IC201.65, SHIELD401.39
PIN40: IC201.66, SHIELD401.40
PIN41: IC201.67, SHIELD401.41
PIN42: IC201.71, SHIELD401.42
PIN43: IC201.72, SHIELD401.43
PIN44: IC201.101, SHIELD401.44
PIN45: IC201.100, SHIELD401.45
PIN46: IC201.99, SHIELD401.46
PIN47: IC201.98, SHIELD401.47
PIN48: IC201.97, SHIELD401.48
PIN49: IC201.96, SHIELD401.49
PIN50: IC201.95, SHIELD401.50
PIN51: IC201.94, SHIELD401.51
PWM2: IC201.144, SHIELD401.2, SJ601.1
PWM3: IC201.139, SHIELD401.3
PWM5: IC201.136, SHIELD401.5
PWM6: IC201.135, SHIELD401.6
PWM7: IC201.134, SHIELD401.7
PWM8: IC201.133, SHIELD401.8
PWM9: IC201.132, SHIELD401.9
PWM11: IC201.20, SHIELD401.11
PWM12: IC201.21, SHIELD401.12
PWM13: IC201.68, SHIELD401.13, U203.3
RXD0: IC201.18, SHIELD401.15
RXD1: IC201.5, SHIELD401.17
RXD2: IC201.3, SHIELD401.19
SCK: IC201.110, IC601.30, SHIELD401.SP3, U701.5
SCL0-3: IC201.87, R207.2, SHIELD401.21, SJ701.1
SCL1: IC201.70, SHIELD401.SCL1
SDA0-3: IC201.86, R205.2, SHIELD401.20, SJ702.1
SDA1: IC201.9, SHIELD401.SDA1
SS0/PWM10: IC201.102, IC201.111, IC601.29, Q601.1, SHIELD401.10
SS1/PWM4: IC201.112, IC201.137, SHIELD401.4, U701.2
TXD0: IC201.17, SHIELD401.14
TXD1: IC201.6, SHIELD401.16
TXD2: IC201.4, SHIELD401.18
VIN: C501.1, C502.1, JP601.4, L501.2, R502.6, R503.1, SHIELD401.V_IN, U502.5

## KiCad design projects/freetronics_ndriveshield_ndriveshield/current_version/working/working.kicad_pcb

File projects/freetronics_ndriveshield_ndriveshield/current_version/working/readme.md:

# ndriveshield
 
## summary 
* id: freetronics_ndriveshield_ndriveshield
* user: freetronics
* name: ndriveshield
* board: ndriveshield
* repo: https://github.com/freetronics/NDriveShield
* src_file_repo_kicad_pcb: NDriveShield.kicad_pcb
* src_file_repo_kicad_pcb_link: https://github.com/freetronics/NDriveShield/tree/master/NDriveShield.kicad_pcb

* src_file_repo_sch: NDriveShield.sch
* src_file_repo_sch_link: https://github.com/freetronics/NDriveShield/tree/master/NDriveShield.sch
* full details link: https://github.com/oomlout/oomlout_oomp_project_bot_v_2/tree/main/projects/freetronics_ndriveshield_ndriveshield/current_version/working

Parts:
JP5: M08; TERMINALBLOCK_3.5MM_8
LED1, LED2, LED3, LED4, LED5, LED6, LED7: LED; LED-0603
Q1, Q2, Q3, Q4, Q5, Q6: NTD5867NLT4G; MOSFET_DPAK
R1, R4: 1K; RES_CAY16
R2, R5: 470R; RES_CAY16
R3, R6: 10K; RES_CAY16
SHIELD1: ARDUINO_SHIELD; ARDUINO_SHIELD_ROUNDPADS_BREAKOUT
SW1: SW_PUSHBUTTON; TACTILE_SWITCH_SMD_2PIN_TINY

Connections:
+5V: R2.7, SHIELD1.5V
/D3: R1.1 (7), R2.5 (7), SHIELD1.3
/D5: R1.3 (7), R2.3 (7), SHIELD1.5
/D6: R1.5 (7), R2.1 (7), SHIELD1.6
/D9: R1.7, R5.5 (7), SHIELD1.9
/D10: R4.3 (7), R5.3 (7), SHIELD1.10
/D11: R4.1 (7), R5.1 (7), SHIELD1.11
/DRAIN1: JP5.2, Q1.D
/DRAIN2: JP5.3, Q2.D
/DRAIN3: JP5.4, Q3.D
/DRAIN4: JP5.5, Q4.D
/DRAIN5: JP5.6, Q5.D
/DRAIN6: JP5.7, Q6.D
/GATE1: Q1.G, R1.2 (8), R3.1 (7)
/GATE2: Q2.G, R1.4 (8), R3.3 (7)
/GATE3: Q3.G, R1.6 (8), R3.5 (7)
/GATE4: Q4.G, R1.8, R3.7
/GATE5: Q5.G, R4.4 (8), R6.3 (7)
/GATE6: Q6.G, R4.2 (8), R6.1 (7)
/IORef: SHIELD1.IO_R (IOREF)
/RESET: SHIELD1.RST, SW1.1
/VIN: JP5.1, SHIELD1.V_IN
GND: JP5.8, LED1.K, LED2.K, LED3.K, LED4.K, LED5.K, LED6.K, LED7.K, Q1.S, Q2.S, Q3.S, Q4.S, Q5.S, Q6.S, R3.2 (8), R3.4 (8), R3.6 (8), R3.8, R6.2 (8), R6.4 (8), SHIELD1.GND1, SHIELD1.GND2, SHIELD1.GND3, SHIELD1.SP6 (Gnd), SW1.2
unnamed: LED1.A, R2.6 (8)
unnamed: LED2.A, R2.4 (8)
unnamed: LED3.A, R2.2 (8)
unnamed: LED4.A, R5.6 (8)
unnamed: LED5.A, R5.4 (8)
unnamed: LED6.A, R5.2 (8)
unnamed: LED7.A, R2.8

Notes on the sheet:
Screw Terminal Inputs
Reset Button

Board: 2 copper layers, 68.5 x 53.2 mm, 23 parts (0 on the bottom side), 29 nets.

Other parts of the board:
LOGO_FREETRONICS: val**; LOGO_FREETRONICS

## KiCad design projects/freetronics_oled128_oled128/current_version/working/working.kicad_pcb

File projects/freetronics_oled128_oled128/current_version/working/readme.md:

# oled128
 
## summary 
* id: freetronics_oled128_oled128
* user: freetronics
* name: oled128
* board: oled128
* repo: https://github.com/freetronics/OLED128
* src_file_repo_kicad_pcb: OLED128.kicad_pcb
* src_file_repo_kicad_pcb_link: https://github.com/freetronics/OLED128/tree/master/OLED128.kicad_pcb

* src_file_repo_sch: OLED128.sch
* src_file_repo_sch_link: https://github.com/freetronics/OLED128/tree/master/OLED128.sch
* full details link: https://github.com/oomlout/oomlout_oomp_project_bot_v_2/tree/main/projects/freetronics_oled128_oled128/current_version/working

Parts:
C1, C5, C9: 1uF; 0603
C2: 10uF 16V; 0603
C3, C11, C12: 100nF; 0603
C4: 4.7uF 25V TANT; 1206
C6: 22pF 25V; 0603
C7: 4.7uF 25V; 0603
C8: 100nF 25V; 0603
C10: 4.7uF; 0603
D1: MBR0540; SOD-123
IC1: TPS61040; SOT23-5
JP1: GPIO1; 1X01
L1: 6.8uH; 1210
LED1, LED2: LED; LED3MM
OLED1: OLED128_UG2828; OLED-128X128-FPC-TOP
P1: M02X05; DIL10
P2: MICROSD; MICRO-SD-SOCKET-PP
P3, P4: M02X02; PIN_ARRAY_2X2
R1: 10K; 0603
R8: 910K 1%; 0603
R9: 82K 1%; 0603
R10: 47R 1/4W; 1206
R11: 4.7k
R17: 560K; 0603
R20, R21: 470; R3
REG1: LP2985-33; MODULE
SW1, SW2: SW_PUSHBUTTON; SW_TC0122
U1: MC74VHCT50A; SOIC14
Z1: 2V4; SOD-123

Connections:
+3.3V: C5.1, C10.1, C11.1, C12.1, OLED1.4 (VDDIO), OLED1.27 (VCI), P2.4 (VCC), REG1.5 (VOUT), U1.14 (VCC)
/MISO: P1.5, P2.7 (DO)
/MOSI: P1.6, U1.9 (4A)
/MOSI_3v3: OLED1.13 (D1), P2.3 (DI), U1.8 (4Y)
/OLED_DnC: P1.9, U1.5 (3A)
/OLED_DnC_3v3: OLED1.20 (D/C#), U1.6 (3Y)
/OLED_VCC: C6.1, C7.1, C8.1, D1.K, OLED1.2 (VCC), R8.1
/OLED_nCS: P1.8, R11.2, U1.13 (6A)
/OLED_nCS_3v3: OLED1.19 (CS#), U1.12 (6Y)
/OLED_nRST: P1.10, U1.3 (2A)
/OLED_nRST_3v3: OLED1.21 (RES#), U1.4 (2Y)
/SCK: P1.7, U1.11 (5A)
/SCK_3v3: OLED1.14 (D0), P2.5 (SCK), U1.10 (5Y)
/VCC_ON: IC1.4 (EN), OLED1.24 (GPIO0), R1.1
/uSD_CD: P1.4, P2.CD1
/uSD_nCS: P1.3, U1.1 (1A)
/uSD_nCS_3v3: P2.2 (CS#), U1.2 (1Y)
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, IC1.2 (GND), OLED1.1 (NC(GND)), OLED1.7 (D7), OLED1.8 (D6), OLED1.9 (D5), OLED1.10 (D4), OLED1.11 (D3), OLED1.15 (E/RD#), OLED1.16 (R/W#), OLED1.17 (BS0), OLED1.18 (BS1), OLED1.28 (VSS), OLED1.30 (NC(GND)), P1.2, P2.6 (GND), P2.CD2, P2.GND1, P2.GND2, R1.2, R9.2, R17.1, REG1.2 (GND), U1.7 (GND), Z1.A
unnamed: OLED1.22 (IREF), R17.2
unnamed: C4.1, OLED1.3 (VCOMH)
unnamed: D1.A, IC1.1 (SW), L1.2
unnamed: R10.2, Z1.K
unnamed: C6.2, IC1.3 (FB), R8.2, R9.1
unnamed: C9.1, OLED1.26 (VDD)
unnamed: OLED1.5 (VSL), R10.1
unnamed: P3.1, R20.2
unnamed: P3.4, SW1.1
unnamed: P3.3, SW1.2
unnamed: P4.3, SW2.2
unnamed: LED2.A, P4.2
unnamed: JP1.1, OLED1.23 (GPIO1)
unnamed: LED1.K, R20.1
unnamed: LED2.K, R21.1
unnamed: LED1.A, P3.2
unnamed: P4.4, SW2.1
unnamed: P4.1, R21.2
VCC: C1.1, C2.1, C3.1, IC1.5 (VIN), L1.1, P1.1, R11.1, REG1.1 (VIN), REG1.3 (ONOFF)

Notes on the sheet:
Arduino Uno Pins: MOSI = 11 MISO = 12 SCK = 13
MicroSD Slot
Optional Expansion on "Wings"
Arduino 6-pin ICSP/SPI header pins: MOSI = 4 MISO = 1 SCK = 3 VCC = 2 Gnd = 6
OLED VCC = 15V Max current draw <50mA
MCU Connector
OLED Connector
Default pins in example sketches (editable): OLED_CS = 2 OLED_DnC = 3 OLED_nRST = 6 uSD nCS=4 (for sketches using MicroSD)
OLED VCC Supply 15V DC
RHS
3.3v Supply
LHS
SPI Level Shifting

Board: 2 copper layers, 45.7 x 34.2 mm, 41 parts (2 on the bottom side), 37 nets.

Other parts of the board:
1PIN, 1PIN#2, 1PIN#3, 1PIN#4: P***; 1pin
Ref**: Val**; LOGO_FREETRONICS_SMALL
