# Repository oomlout/oomlout_oomp_project_bot_v_2

## KiCad design projects/gigahawk_kicad_templates_alchitry_au/current_version/working/working.kicad_pcb

File projects/gigahawk_kicad_templates_alchitry_au/current_version/working/readme.md:

# kicad_templates
 
## summary 
* id: gigahawk_kicad_templates_alchitry_au
* user: gigahawk
* name: kicad_templates
* board: alchitry_au
* repo: https://github.com/Gigahawk/kicad_templates
* src_file_repo_kicad_pcb: Alchitry_Au/Alchitry_Au.kicad_pcb
* src_file_repo_kicad_pcb_link: https://github.com/Gigahawk/kicad_templates/tree/master/Alchitry_Au/Alchitry_Au.kicad_pcb

* src_file_repo_sch: Alchitry_Au/Alchitry_Au.sch
* src_file_repo_sch_link: https://github.com/Gigahawk/kicad_templates/tree/master/Alchitry_Au/Alchitry_Au.sch
* full details link: https://github.com/oomlout/oomlout_oomp_project_bot_v_2/tree/main/projects/gigahawk_kicad_templates_alchitry_au/current_version/working

Board: 2 copper layers, 8 parts (0 on the bottom side), 3 nets, no tracks yet.

Parts:
B1, B2, B3, B4: Alchitry_Shield; Alchitry_Conn
H1, H2, H3, H4: MountingHole; 2m2ThroughHole

Connections:
+3V3: B1.B7, B1.B13, B1.B19, B1.B25, B1.B26, B1.B32, B1.B38, B1.B44, B2.B7, B2.B13, B2.B19, B2.B25, B2.B26, B2.B32, B2.B38, B2.B44, B3.B7, B3.B13, B3.B19, B3.B25, B3.B26, B3.B32, B3.B38, B3.B44, B4.B7, B4.B13, B4.B19, B4.B25, B4.B26, B4.B32, B4.B38, B4.B44
+5V: B1.B1, B1.B50, B2.B1, B2.B50, B3.B1, B3.B50, B4.B50
GND: B1.B4, B1.B10, B1.B16, B1.B22, B1.B29, B1.B35, B1.B41, B1.B47, B2.B4, B2.B10, B2.B16, B2.B22, B2.B29, B2.B35, B2.B41, B2.B47, B3.B4, B3.B10, B3.B16, B3.B22, B3.B29, B3.B35, B3.B41, B3.B47, B4.B4, B4.B10, B4.B16, B4.B22, B4.B29, B4.B35, B4.B41, B4.B47
