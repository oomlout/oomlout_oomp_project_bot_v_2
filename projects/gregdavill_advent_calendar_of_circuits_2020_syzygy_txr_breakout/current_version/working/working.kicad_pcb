# Repository oomlout/oomlout_oomp_project_bot_v_2 (continued)

## KiCad design projects/gregdavill_boson_sd_hardware_crushedice/current_version/working/working.kicad_pcb

File projects/gregdavill_boson_sd_hardware_crushedice/current_version/working/readme.md:

# boson_sd_hardware
 
## summary 
* id: gregdavill_boson_sd_hardware_crushedice
* user: gregdavill
* name: boson_sd_hardware
* board: crushedice
* repo: https://github.com/gregdavill/boson-sd-hardware
* src_file_repo_kicad_pcb: hw/bosonBreakout/crushedICE.kicad_pcb
* src_file_repo_kicad_pcb_link: https://github.com/gregdavill/boson-sd-hardware/tree/master/hw/bosonBreakout/crushedICE.kicad_pcb

* src_file_repo_sch: 
* src_file_repo_sch_link: https://github.com/gregdavill/boson-sd-hardware/tree/master/
* full details link: https://github.com/oomlout/oomlout_oomp_project_bot_v_2/tree/main/projects/gregdavill_boson_sd_hardware_crushedice/current_version/working

Board: 4 copper layers, 100.0 x 50.0 mm, 68 parts (0 on the bottom side), 89 nets.

Parts:
C1: 10uF; C_0805
C2, C3, C13, C18, C19, C20, C21, C22, C23, C24, C25, C26, C27, C28, C29, C30, C31: 100n; C_0603
C4, C5, C6: 22nF; C_0603
C7, C8: 22uF; C_0805
C9, C10, C11, C12, C14: 1uF; C_0603
C15: 10n; C_0603
C16, C17: 26pF; C_0603
D1, D2, D3, D4, D5, D6: led green; LED_0805
J1, J2: Conn_02x12_Odd_Even; Pin_Header_Straight_2x12_Pitch2.54mm
J3: MicroSD; SD_holder_472190001
J4: USB_OTG; USB_Micro-B_10103594-0001LF
J5: Conn_02x05_Odd_Even; Pin_Header_Straight_2x05_Pitch2.54mm
J6: cortex SWD; CORTEX_SWD
J7: Conn_01x10; Pin_Header_Straight_1x10_Pitch2.54mm
JP1: Jumper_NC_Small; R_0201_NoSilk
L1: 4u7; Inductor_Taiyo-Yuden_MD-3030
R2: 2.0K; R_0603
R3, R5, R7, R9, R11: 10K; R_0603
R4: 15K; R_0603
R6: 17.8K; R_0603
R8: 8.0K; R_0603
R10: 23K; R_0603
R12: 1K; R_0603
RN1, RN2: R_Pack04; R_Array_Convex_4x0603
U1: ICE5LP4K-SG48; QFN-48-1EP_7x7mm_Pitch0.5mm
U2: S27KS0641; BGA_24
U4: Boson; DF40_80Pin
U5: ATSAMD51G19A; QFN-48-1EP_7x7mm_Pitch0.5mm
U6, U7: SC560A; MLPQ-UT8
U8: TS30011; QFN-16-1EP_3x3mm_Pitch0.5mm_ThermalVias
U10: TXS02612; QFN-24-1EP_4x4mm_Pitch0.5mm
Y1: 16MHz; Crystal_SMD_3225-4pin_3.2x2.5mm

Connections:
+1V2: C10.1, C25.1, C27.1, C29.1, J7.5, R2.2, U1.5, U1.29, U1.30, U6.3
+1V8: C11.1, C20.1, C21.1, C22.1, C23.1, C24.1, C26.1, C28.1, C30.1, J6.1, J7.4, R8.2, R12.1, U1.1, U1.22, U1.33, U2.B4, U2.D1, U2.E4, U5.6, U5.17, U5.36, U5.44, U6.1, U7.6, U10.5
+2V5: C12.1, C31.1, J7.3, R4.2, U1.24, U7.3
+3V3: C7.1, C8.1, C18.1, C19.1, J3.4, J7.2, L1.1, R6.1, RN1.5, RN1.6, RN1.7, RN1.8, RN2.5, RN2.6, RN2.7, RN2.8, U4.2, U4.4, U4.6, U4.8, U10.17, U10.21
+5V: C1.1, C2.1, C3.1, C13.1, C15.1, J7.1, JP1.2, U6.2, U6.6, U7.2, U8.2, U8.3, U8.11
/Microcontroller/VUSB: J4.1, JP1.1
/Microcontroller/XOSC1_XIN: C16.2, U5.23, Y1.1
/Microcontroller/XOSC1_XOUT: C17.2, U5.24, Y1.3
BOSON_RXD: J1.2, U4.33, U5.1
BOSON_TXD: J1.1, U4.43, U5.2
CAM_CLK: J1.21, U1.45, U4.55
CAM_D0: J1.3, U1.43, U4.77
CAM_D1: J1.4, U1.44, U4.62
CAM_D2: J1.5, U1.47, U4.51
CAM_D3: J1.6, U1.46, U4.56
CAM_D4: J1.7, U1.11, U4.27
CAM_D5: J1.8, U1.13, U4.28
CAM_D6: J1.9, U1.12, U4.32
CAM_D7: J1.10, U1.10, U4.31
CAM_D8: J1.11, U1.18, U4.25
CAM_D9: J1.12, U1.3, U4.46
CAM_D10: J1.13, U1.4, U4.45
CAM_D11: J1.14, U1.2, U4.48
CAM_D12: J1.15, U1.48, U4.47
CAM_D13: J1.16, U1.6, U4.41
CAM_D14: J1.17, U1.19, U4.21
CAM_D15: J1.18, U1.9, U4.38
CAM_HSYNC: J1.24, U4.73
CAM_VALID: J1.22, U1.42, U4.78, U5.3
CAM_VSYNC: J1.23, U4.53
CDONE/IO_C: J2.22, U1.7, U5.29
DEBUG_TX: J2.24, U5.32
FPGA_CS: J2.20, U1.16, U5.28
FPGA_RST: U1.8, U5.26
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, C13.2, C14.2, C15.2, C16.1, C17.1, C18.2, C19.2, C20.2, C21.2, C22.2, C23.2, C24.2, C25.2, C26.2, C27.2, C28.2, C29.2, C30.2, C31.2, J1.19, J1.20, J2.1, J2.2, J2.16, J3.6, J3.9, J4.5, J4.6, J5.10, J6.3, J6.5, J7.6, J7.7, J7.8, J7.9, J7.10, R3.2, R5.2, R7.2, R9.2, R11.2, U1.49, U2.B3, U2.C1, U2.E5, U4.1, U4.3, U4.5, U4.7, U4.10, U4.13, U4.19, U4.20, U4.29, U4.30, U4.39, U4.40, U4.49, U4.50, U4.59, U4.60, U4.69, U4.70, U4.79, U5.5, U5.18, U5.35, U5.42, U5.49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
HB_CK: J2.11, U1.25, U2.B2
HB_CK#: J2.12, U1.23, U2.B1
HB_CS#: J2.14, U1.26, U2.A3
HB_DQ0: J2.3, U1.32, U2.D3
HB_DQ1: J2.4, U1.28, U2.D2
HB_DQ2: J2.5, U1.37, U2.C4
HB_DQ3: J2.6, U1.36, U2.D4
HB_DQ4: J2.7, U1.38, U2.D5
HB_DQ5: J2.8, U1.34, U2.E3
HB_DQ6: J2.9, U1.31, U2.E2
HB_DQ7: J2.10, U1.27, U2.E1
HB_RESET#: J2.13, U2.A4
HB_RWDS: J2.15, U1.35, U2.C3
LED_A: D1.1, U1.39
LED_B: D2.1, U1.40
LED_C: D3.1, U1.41
LED_D: D4.1, U5.47
LED_E: D5.1, U5.48
LED_F: D6.1, U5.7
unnamed: C4.1, U6.7
unnamed: C5.1, U7.7
unnamed: C6.1, L1.2, U8.1, U8.12, U8.13, U8.16
unnamed: C6.2, U8.10
unnamed: C9.1, R10.2, U7.1
unnamed: C14.1, U5.41
unnamed: D1.2, RN1.1
unnamed: D2.2, RN1.2
unnamed: D3.2, RN1.3
unnamed: D4.2, RN2.1
unnamed: D5.2, RN2.2
unnamed: D6.2, RN2.3
unnamed: R2.1, R3.1, U6.4
unnamed: R4.1, R5.1, U7.4
unnamed: R6.2, R7.1, U8.5
unnamed: R8.1, R9.1, U6.8
unnamed: R10.1, R11.1, U7.8
SAM_RST: J6.10, U5.40
SAM_SWCLK: J6.4, R12.2, U5.45
SAM_SWDIO: J6.2, U5.46
SDMMC_SEL: J5.9, U5.12, U10.24
SD_CK/QSPI_CS: U5.20, U5.25, U10.9
SD_CLK: J3.5, J5.6, U10.19
SD_CMD: J3.3, J5.5, U10.20
SD_CMD/QSPI_D0: J2.17, U1.17, U5.13, U10.4
SD_D0: J3.7, J5.7, U10.18
SD_D1: J3.8, J5.8, U10.16
SD_D2: J3.1, J5.3, U10.23
SD_D3: J3.2, J5.4, U10.22
SD_DAT0/QSPI_D1: J2.19, U1.14, U5.14, U10.6
SD_DAT1/QSPI_D2: J2.21, U1.20, U5.15, U10.7
SD_DAT2/QSPI_D3: J2.23, U1.21, U5.16, U10.1
SD_DAT3/QSPI_SCK: J2.18, U1.15, U5.19, U10.3
USB_DATA_N: J4.2, J5.1, U5.33
USB_DATA_P: J4.3, J5.2, U5.34

## KiCad design projects/gregdavill_bosonadapters_leptonadapter/current_version/working/working.kicad_pcb

File projects/gregdavill_bosonadapters_leptonadapter/current_version/working/readme.md:

# bosonadapters
 
## summary 
* id: gregdavill_bosonadapters_leptonadapter
* user: gregdavill
* name: bosonadapters
* board: leptonadapter
* repo: https://github.com/gregdavill/bosonAdapters
* src_file_repo_kicad_pcb: hw/Lepton/LeptonAdapter.kicad_pcb
* src_file_repo_kicad_pcb_link: https://github.com/gregdavill/bosonAdapters/tree/master/hw/Lepton/LeptonAdapter.kicad_pcb

* src_file_repo_sch: hw/Lepton/LeptonAdapter.sch
* src_file_repo_sch_link: https://github.com/gregdavill/bosonAdapters/tree/master/hw/Lepton/LeptonAdapter.sch
* full details link: https://github.com/oomlout/oomlout_oomp_project_bot_v_2/tree/main/projects/gregdavill_bosonadapters_leptonadapter/current_version/working

Board: 4 copper layers, 21.0 x 21.0 mm, 19 parts (18 on the bottom side), 26 nets.

Parts:
C1, C2, C3, C4, C5: 1uF; C_0603
C6, C7, C8, C9, C10, C11: 100n; C_0603
LEP1: LEPTON; 1050281001
R1: 10k; R_0603
U1: Boson_Slave; DF40_80Pin
U2, U3, U6: TLV733P; X2SON
U4: TXS0102; VSSOP-8_2.3x2mm_Pitch0.5mm
U5: TB0108; TSSOP-20_4.4x6.5mm_Pitch0.65mm

Connections:
+1V2: C2.1, C10.1, LEP1.7, U2.1
+1V8: C1.1, C7.1, C8.1, U4.3, U5.2, U6.1
+2V8: C3.1, C9.1, C11.1, LEP1.16, LEP1.19, U3.1, U4.7, U5.19
+3V3: C4.1, C5.1, C6.1, U1.2, U1.4, U1.6, U1.8, U2.3, U2.4, U3.3, U3.4, U6.3, U6.4
/IIC_SCL: U1.62, U4.4
/IIC_SDA: U1.78, U4.5
/LEP_CLK: LEP1.13, U5.18
/LEP_CS: LEP1.14, U5.20
/LEP_MCLK: LEP1.26, U5.13
/LEP_MISO: LEP1.12, U5.17
/LEP_MOSI: LEP1.11, U5.16
/LEP_PWRDWN: LEP1.23, U5.14
/LEP_RST: LEP1.24, U5.15
/LEP_SCL: LEP1.21, U4.1
/LEP_SDA: LEP1.22, U4.8
/LEP_VSYNC: LEP1.2, U5.12
/MCLK: U1.24, U5.8
/OE: R1.1, U1.72, U4.6, U5.10
/POWER_DOWN: U1.27, U5.7
/RESET: U1.28, U5.6
/SPI_CLK: U1.38, U5.3
/SPI_CS: U1.41, U5.1
/SPI_MISO: U1.31, U5.4
/SPI_MOSI: U1.32, U5.5
/VSYNC: U1.25, U5.9
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, LEP1.1, LEP1.6, LEP1.8, LEP1.9, LEP1.10, LEP1.15, LEP1.18, LEP1.20, LEP1.25, LEP1.27, LEP1.30, LEP1.33, R1.2, U1.1, U1.3, U1.5, U1.7, U1.10, U1.13, U1.19, U1.20, U1.29, U1.30, U1.39, U1.40, U1.49, U1.50, U1.59, U1.60, U1.69, U1.70, U1.79, U2.2, U3.2, U4.2, U5.11, U6.2

## KiCad design projects/gregdavill_cap_sense_flex_rx/current_version/working/working.kicad_pcb

File projects/gregdavill_cap_sense_flex_rx/current_version/working/readme.md:

# cap_sense_flex
 
## summary 
* id: gregdavill_cap_sense_flex_rx
* user: gregdavill
* name: cap_sense_flex
* board: rx
* repo: https://github.com/gregdavill/cap-sense-flex
* src_file_repo_kicad_pcb: hardware/Rx-r0.1/Rx.kicad_pcb
* src_file_repo_kicad_pcb_link: https://github.com/gregdavill/cap-sense-flex/tree/main/hardware/Rx-r0.1/Rx.kicad_pcb
* src_file_repo_kicad_sch: hardware/Rx-r0.1/Rx.kicad_sch
* src_file_repo_kicad_sch_link: https://github.com/gregdavill/cap-sense-flex/tree/main/hardware/Rx-r0.1/Rx.kicad_sch

* src_file_repo_sch: 
* src_file_repo_sch_link: https://github.com/gregdavill/cap-sense-flex/tree/main/
* full details link: https://github.com/oomlout/oomlout_oomp_project_bot_v_2/tree/main/projects/gregdavill_cap_sense_flex_rx/current_version/working

Parts:
J1: Conn_01x08_Male; 8P_0.5mm_FFC
TP1, TP2, TP3, TP4, TP5, TP6, TP7, TP8: CapSense

Connections:
unnamed: J1.1, TP7.1
unnamed: J1.2, TP5.1
unnamed: J1.3, TP3.1
unnamed: J1.4, TP1.1
unnamed: J1.5, TP2.1
unnamed: J1.6, TP4.1
unnamed: J1.7, TP6.1
unnamed: J1.8, TP8.1

Board: 2 copper layers, 150.0 x 8.0 mm, 9 parts (0 on the bottom side), 8 nets.

## KiCad design projects/gregdavill_cap_sense_flex_tx/current_version/working/working.kicad_pcb

File projects/gregdavill_cap_sense_flex_tx/current_version/working/readme.md:

# cap_sense_flex
 
## summary 
* id: gregdavill_cap_sense_flex_tx
* user: gregdavill
* name: cap_sense_flex
* board: tx
* repo: https://github.com/gregdavill/cap-sense-flex
* src_file_repo_kicad_pcb: hardware/Tx-r0.1/Tx.kicad_pcb
* src_file_repo_kicad_pcb_link: https://github.com/gregdavill/cap-sense-flex/tree/main/hardware/Tx-r0.1/Tx.kicad_pcb
* src_file_repo_kicad_sch: hardware/Tx-r0.1/Tx.kicad_sch
* src_file_repo_kicad_sch_link: https://github.com/gregdavill/cap-sense-flex/tree/main/hardware/Tx-r0.1/Tx.kicad_sch

* src_file_repo_sch: 
* src_file_repo_sch_link: https://github.com/gregdavill/cap-sense-flex/tree/main/
* full details link: https://github.com/oomlout/oomlout_oomp_project_bot_v_2/tree/main/projects/gregdavill_cap_sense_flex_tx/current_version/working

Parts:
J1: Conn_01x08_Male; 8P_0.5mm_FFC
TP1, TP2, TP3, TP4, TP5, TP6, TP7, TP8: TestPoint_2Pole; CapSenseTx

Connections:
unnamed: J1.1, TP1.2, TP2.2, TP3.2, TP4.2, TP5.2, TP6.2, TP7.2, TP8.2
unnamed: J1.8, TP1.1, TP2.1, TP3.1, TP4.1, TP5.1, TP6.1, TP7.1, TP8.1

Board: 2 copper layers, 150.0 x 8.0 mm, 9 parts (0 on the bottom side), 2 nets.
