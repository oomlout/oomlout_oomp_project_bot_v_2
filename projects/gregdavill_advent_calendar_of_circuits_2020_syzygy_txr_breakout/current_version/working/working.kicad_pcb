# Repository oomlout/oomlout_oomp_project_bot_v_2

## KiCad design projects/gregdavill_advent_calendar_of_circuits_2020_syzygy_txr_breakout/current_version/working/working.kicad_pcb

File projects/gregdavill_advent_calendar_of_circuits_2020_syzygy_txr_breakout/current_version/working/readme.md:

# advent_calendar_of_circuits_2020
 
## summary 
* id: gregdavill_advent_calendar_of_circuits_2020_syzygy_txr_breakout
* user: gregdavill
* name: advent_calendar_of_circuits_2020
* board: syzygy_txr_breakout
* repo: https://github.com/gregdavill/advent-calendar-of-circuits-2020
* src_file_repo_kicad_pcb: syzygy-txr-breakout/kicad-src/syzygy-txr-breakout.kicad_pcb
* src_file_repo_kicad_pcb_link: https://github.com/gregdavill/advent-calendar-of-circuits-2020/tree/main/syzygy-txr-breakout/kicad-src/syzygy-txr-breakout.kicad_pcb
* src_file_repo_kicad_sch: syzygy-txr-breakout/kicad-src/pMCU.kicad_sch
* src_file_repo_kicad_sch_link: https://github.com/gregdavill/advent-calendar-of-circuits-2020/tree/main/syzygy-txr-breakout/kicad-src/pMCU.kicad_sch

* src_file_repo_sch: 
* src_file_repo_sch_link: https://github.com/gregdavill/advent-calendar-of-circuits-2020/tree/main/
* full details link: https://github.com/oomlout/oomlout_oomp_project_bot_v_2/tree/main/projects/gregdavill_advent_calendar_of_circuits_2020_syzygy_txr_breakout/current_version/working

Board: 4 copper layers, 50.0 x 80.0 mm, 35 parts (5 on the bottom side), 41 nets.

Parts:
C9, C32: 0.1uF; C_0402_1005Metric
C10: 1uF; C_0402_1005Metric
H1, H2, H3, H4: MountingHole; MountingHole_3.2mm_M3
J1: SYZYGY-TXR-4; SYZYGY-TXR-POD
J2, J4, J5, J6, J7, J8, J13, J14, J15, J16, J17, J18, J19, J20, J21, J22, J23, J24: sma jack; SMA_Amphenol_132134_Vertical
J3: TagConnect; TC2030-NL_SMALL
J9: Conn_02x07_Odd_Even; PinHeader_2x07_P2.54mm_Vertical
J10, J11, J12: Conn_01x01_Male; PinHeader_1x01_P2.54mm_Vertical
R15: 10K; R_0402_1005Metric
R16: 100R; R_0402_1005Metric
U2: ATtiny44A-MMH; QFN-20-1EP_3x3mm_P0.45mm_EP1.6x1.6mm
X1: SG3225VAN; Oscillator_SMD_Silicon_Labs_LGA-6_2.5x3.2mm_P1.25mm

Connections:
+3V3: C9.1, C10.1, C32.1, J1.40 (+3.3V), J3.2, J11.1, R15.1, U2.9 (VCC), X1.1 (OE), X1.6 (Vcc)
+5V: J1.2 (+5V), J10.1
/C2P_CLK_N: J1.36 (C2P_CLKN), J9.14
/C2P_CLK_P: J1.34 (C2P_CLKP), J9.12
/P2C_CLK_N: J1.35 (P2C_CLKN), J9.13
/P2C_CLK_P: J1.33 (P2C_CLKP), J9.11
/Peripheral MCU/MISO: J3.1, U2.20 (PA5)
/Peripheral MCU/~RESET: J3.5, U2.13 (~RESET~/PB3)
/REFCLK_N: J1.15 (REFCLKN), J6.1 (In), R16.1, X1.5 (~OUT)
/REFCLK_P: J1.13 (REFCLKP), J2.1 (In), R16.2, X1.4 (OUT)
/RGA: J1.4 (R_GA), R15.2, U2.5 (AREF/PA0)
/RX0_N: J1.7 (RX0N), J7.1 (In)
/RX0_P: J1.5 (RX0P), J4.1 (In)
/RX1_N: J1.11 (RX1N), J15.1 (In)
/RX1_P: J1.9 (RX1P), J13.1 (In)
/RX2_N: J1.31 (RX2N), J19.1 (In)
/RX2_P: J1.29 (RX2P), J17.1 (In)
/RX3_N: J1.27 (RX3N), J23.1 (In)
/RX3_P: J1.25 (RX3P), J21.1 (In)
/S0: J1.14 (S0), J9.1
/S1: J1.16 (S1), J9.2
/S2: J1.17 (S2), J9.3
/S3: J1.18 (S3), J9.4
/S4: J1.19 (S4), J9.5
/S5: J1.20 (S5), J9.6
/S6: J1.21 (S6), J9.7
/S7: J1.22 (S7), J9.8
/S8: J1.23 (S8), J9.9
/S9: J1.24 (S9), J9.10
/SCL: J1.1 (SCL), J3.3, U2.1 (PA4)
/SDA: J1.3 (SDA), J3.4, U2.16 (PA6)
/TX0_N: J1.8 (TX0N), J8.1 (In)
/TX0_P: J1.6 (TX0P), J5.1 (In)
/TX1_N: J1.12 (TX1N), J16.1 (In)
/TX1_P: J1.10 (TX1P), J14.1 (In)
/TX2_N: J1.32 (TX2N), J20.1 (In)
/TX2_P: J1.30 (TX2P), J18.1 (In)
/TX3_N: J1.28 (TX3N), J24.1 (In)
/TX3_P: J1.26 (TX3P), J22.1 (In)
/VCCIO: J1.39 (VIO1), J12.1
GND: C9.2, C10.2, C32.2, J1.41 (GND), J2.2 (Ext), J3.6, J4.2 (Ext), J5.2 (Ext), J6.2 (Ext), J7.2 (Ext), J8.2 (Ext), J13.2 (Ext), J14.2 (Ext), J15.2 (Ext), J16.2 (Ext), J17.2 (Ext), J18.2 (Ext), J19.2 (Ext), J20.2 (Ext), J21.2 (Ext), J22.2 (Ext), J23.2 (Ext), J24.2 (Ext), U2.8 (GND), U2.21 (GND), X1.3 (GND)

## KiCad design projects/gregdavill_arctickoala_arctic_koala/current_version/working/working.kicad_pcb

File projects/gregdavill_arctickoala_arctic_koala/current_version/working/readme.md:

# arctickoala
 
## summary 
* id: gregdavill_arctickoala_arctic_koala
* user: gregdavill
* name: arctickoala
* board: arctic_koala
* repo: https://github.com/gregdavill/ArcticKoala
* src_file_repo_kicad_pcb: hw/ArcticKoala-r0.1/arctic-koala.kicad_pcb
* src_file_repo_kicad_pcb_link: https://github.com/gregdavill/ArcticKoala/tree/main/hw/ArcticKoala-r0.1/arctic-koala.kicad_pcb

* src_file_repo_sch: hw/ArcticKoala-r0.1/arctic-koala.sch
* src_file_repo_sch_link: https://github.com/gregdavill/ArcticKoala/tree/main/hw/ArcticKoala-r0.1/arctic-koala.sch
* full details link: https://github.com/oomlout/oomlout_oomp_project_bot_v_2/tree/main/projects/gregdavill_arctickoala_arctic_koala/current_version/working

Parts:
C1, C2, C3, C4, C5, C8, C11, C12, C13, C14, C15, C16, C17, C18, C19, C20, C21, C22, C23, C24, C25, C26, C27, C28, C29, C30, C31, C35, C36, C37, C38, C39, C40, C44, C47: 100n; C_0402
C6, C9: 4u7; C_0603
C7, C41, C45: 22pF; C_0402
C10, C42, C46, C48, C49, C50: 4.7uF; C_0402
C32, C33, C34, C43: 10uF; C_0603
D1: BLUE; D_0603
D2: GREEN; D_0603
D5: RED; D_0603
J1, J2, J18, J29: Jumper; J_NC_0603_15
J3: Conn_02x07_Odd_Even; PinSocket_2x07_P2.54mm_Vertical
J20: Flash; Pin_Header_Straight_1x07
J21, J22, J23: PMOD; Socket_Strip_Angled_2x06
J26, J27: 5V AUX; Pin_Header_Straight_2x01
L1, L2: 600; L_0402
L3, L4, L5: 1.0uH; L_0603_1608Metric
P1: pkl_USB_OTG; Connector_USB_Micro_B_SMD
P2, P3, P4, P5: UP; PAD_SMD_1x2.65
R1: 1M; R_0402
R2, R11: 10k; R_Array_Convex_4x0402
R3, R29: 4k7; R_0402
R4, R20, R21, R22, R23, R24: 33E; R_Array_Convex_4x0402
R5, R6, R7, R10, R27, R28: 2k2; R_0402
R8: 12k; R_0402
R9, R13: 10k; R_0402
R12: 450k; R_0402
R14: 30R; R_0402
R15, R30: 330E; R_0402
R16: 100k; R_0402
R17: 120k; R_0402
R18, R25: 180k; R_0402
R19: 360k; R_0402
R26: 470R; R_0402
SW1: TACT; SW_SPST_3x4x2.5
U1: 93C46B-SOT-23-6; SOT-23-6
U2: PSRAM; SOIC-8_5.3x5.3mm_Pitch1.27mm
U3, U8, U9: TPD4EUSB30; USON-10_2.5x1.0mm_P0.5mm
U4: FT2232H; QFN-64-4.45mm1EP_9x9mm_Pitch0.5mm
U5: W25Q128JV-DTR; SOIC-8_5.3x5.3mm_Pitch1.27mm
U6: LIFCL40-NX; QFN-72-1EP_10x10mm_P0.5mm_EP6x6mm
U7: 12MHz; SOT-23-5
U10, U11, U12: TPS62067; WSON-8-1EP_2x2mm_P0.5mm_EP0.9x1.6mm_ThermalVias

Connections:
+1V0: C2.1, C3.1, C5.1, C7.1, C8.1, C10.1, C11.1, C15.1, C23.1, C24.1, C25.1, C39.1, C48.1, L4.2, R17.1, U6.5 (VCC), U6.6 (VCC), U6.12 (VCCPLL_LLC), U6.21 (VCC), U6.35 (VCC), U6.38 (VCCPLL_LRC), U6.40 (VCC), U6.62 (VCC), U6.63 (VCCPLLDPHY0), U6.70 (VCCDPHY0), U6.72 (VCCDPHY0)
+1V8: C14.1, C16.1, C17.1, C28.1, C29.1, C30.1, C31.1, C35.1, C36.1, C37.1, C38.1, C45.1, C46.1, C49.1, L5.2, R13.2, R19.1, U4.12 (VCORE), U4.37 (VCORE), U4.64 (VCORE), U6.7 (VCCAUX), U6.17 (VCCAUXH5), U6.18 (VCCIO5), U6.26 (VCCIO3), U6.29 (VCCAUXH3), U6.32 (VCCIO3), U6.39 (VCCADC18), U6.47 (VCCAUX), U6.71 (VCCADPHY0)
+3V3: C1.1, C4.1, C18.1, C19.1, C20.1, C21.1, C22.1, C26.1, C27.1, C32.2, C33.2, C34.2, C40.1, C41.1, C42.1, C44.1, C47.1, C50.1, J3.13, J3.14, J21.6, J21.12, J22.6, J22.12, J23.6, J23.12, L1.1, L2.1, L3.2, R2.2, R2.4, R2.6, R2.7, R3.2, R5.2, R9.2, R10.1, R11.1, R11.3, R11.5, R11.7, R12.1, R15.2, R29.2, R30.2, U1.6 (VCC), U2.8 (VCC), U4.20 (VCCIO), U4.31 (VCCIO), U4.42 (VCCIO), U4.56 (VCCIO), U5.8 (VCC), U6.49 (VCCIO1), U6.54 (VCCIO0), U7.4 (VDD), U11.5 (EN), U11.7 (AVIN), U11.8 (PVIN), U12.5 (EN), U12.7 (AVIN), U12.8 (PVIN)
+5V: C43.1, J26.1, J27.1, P1.1 (VCC), P2.1, U10.5 (EN), U10.7 (AVIN), U10.8 (PVIN)
/CK_N: J3.2, U6.69 (DPHY0_CKN), U8.2 (D1-)
/CK_P: J3.1, U6.68 (DPHY0_CKP), U8.1 (D1+)
/D0N: J3.4, U6.3 (DPHY0_DN0), U9.1 (D1+)
/D0P: J3.3, U6.4 (DPHY0_DP0), U9.2 (D1-)
/D1N: J3.6, U3.5 (D2-), U6.67 (DPHY0_DN1)
/D1P: J3.5, U3.4 (D2+), U6.66 (DPHY0_DP1)
/D2N: J3.8, U6.2 (DPHY0_DN2), U8.5 (D2-)
/D2P: J3.7, U6.1 (DPHY0_DP2), U8.4 (D2+)
/D3N: J3.10, U3.2 (D1-), U6.65 (DPHY0_DN3)
/D3P: J3.9, U3.1 (D1+), U6.64 (DPHY0_DP3)
/FLASH_CS: J18.1, J20.1, R11.8, U5.1 (~CS), U6.56 (PT78A/MCSN/PCLKT0_1)
/FLASH_MISO|IO1: J20.4, U2.2 (DO/IO1), U4.18 (ADBUS2), U5.2 (DO/IO1), U6.51 (PT80A/MISO/MD1)
/FLASH_MOSI|IO0: J20.3, U2.5 (DI/IO0), U4.17 (ADBUS1), U5.5 (DI/IO0), U6.57 (PT78B/MOSI/MD0)
/FLASH_~HLD|~RST|IO3: J20.6, R11.2, U2.7 (~HLD/~RST/IO3), U5.7 (~HLD/~RST/IO3), U6.52 (PT82A/MD3)
/FLASH_~WP|IO2: J20.5, R11.6, U2.3 (~WP/IO2), U5.3 (~WP/IO2), U6.55 (PT80B/MD2)
/FTDI_CLK: R14.2, U4.2 (OSCI), U7.5 (OUT)
/P1A1: R20.1, U6.11 (PB8A/PCLKT5_1/LLC_GPLL0T_IN/ADC_CP3)
/P1A1x: J21.1, R20.2
/P1A2: R20.5, U6.9 (PB12A/PCLKT5_3)
/P1A2x: J21.2, R20.6
/P1A3: R23.1, U6.16 (PB6A/PCLKT5_0/CDR_RXP1/ADC_CP1/COMP2P)
/P1A3x: J21.3, R23.2
/P1A4: R23.5, U6.14 (PB4A/CDR_RXP0/VREF5_1/ADC_CP0/COMP1P)
/P1A4x: J21.4, R23.6
/P1A7: R20.3, U6.10 (PB8B/PCLKC5_1/LLC_GPLL0C_IN/ADC_CN3)
/P1A7x: J21.7, R20.4
/P1A8: R20.7, U6.8 (PB12B/PCLKC5_3/VREF5_2)
/P1A8x: J21.8, R20.8
/P1A9: R23.3, U6.15 (PB6B/PCLKC5_0/CDR_RXN1/ADC_CN1/COMP2N)
/P1A9x: J21.9, R23.4
/P1A10: R23.7, U6.13 (PB4B/CDR_RXN0/ADC_CN0/COMP1N)
/P1A10x: J21.10, R23.8
/P1B1: R21.1, U6.25 (PB58B/PCLKC3_1/ADC_CN6)
/P1B1x: J22.1, R21.2
/P1B2: R21.5, U6.23 (PB54B/PCLKC3_0/ADC_CN5)
/P1B2x: J22.2, R21.6
/P1B3: R24.1, U6.34 (PB74B/PCLKC3_3/ADC_CN14)
/P1B3x: J22.3, R24.2
/P1B4: R24.5, U6.31 (PB72B/PCLKC3_2/ADC_CN13)
/P1B4x: J22.4, R24.6
/P1B7: R21.3, U6.24 (PB58A/PCLKT3_1/ADC_CP6)
/P1B7x: J22.7, R21.4
/P1B8: R21.7, U6.22 (PB54A/PCLKT3_0/VREF3_1/ADC_CP5)
/P1B8x: J22.8, R21.8
/P1B9: R24.3, U6.33 (PB74A/PCLKT3_3/ADC_CP14)
/P1B9x: J22.9, R24.4
/P1B10: R24.7, U6.30 (PB72A/PCLKT3_2/ADC_CP13)
/P1B10x: J22.10, R24.8
/P2_1: R4.1, U6.53 (PT82B/MCSNO/MSDO)
/P2_1x: J23.1, R4.2
/P2_2: R4.5, U6.46 (PR8B/TDI/SSI)
/P2_2x: J23.2, R4.6
/P2_3: R22.1, U6.44 (PR11B/SCL/USER_SCL)
/P2_3x: J23.3, R22.2
/P2_4: R22.5, U6.42 (PR11A/SDA/USER_SDA)
/P2_4x: J23.4, R22.6
/P2_7: R4.3, U6.48 (PR6B/TMS/SCSN)
/P2_7x: J23.7, R4.4
/P2_8: R4.7, U6.45 (PR10B/TDO/SSO)
/P2_8x: J23.8, R4.8
/P2_9: R22.3, U6.43 (PR13B/PMU_WAKEUP)
/P2_9x: J23.9, R22.4
/P2_10: R22.7, U6.41 (PR13A/TCK/SCLK/PMU_EXT_CLK)
/P2_10x: J23.10, R22.8
/PSRAM_CS: R29.1, U2.1 (~CS), U6.20 (PB10B/PCLKC5_2/ADC_CN2/COMP3N)
/Rx_TTL|FIFO_D0: J1.2, R27.1
/SPI_CS: J29.1, U4.19 (ADBUS3)
/Tx_TTL|FIFO_D1: J2.2, U6.36 (PB84A/LRC_GPLL0T_IN)
/USB_DM: P1.2 (D-), P3.1, U4.7 (DM)
/USB_DP: P1.3 (D+), P4.1, U4.8 (DP)
/iCE_CDONE: D1.A, R5.1, U4.23 (ADBUS6), U6.58 (PT76B/DONE)
/iCE_CRESET: R3.1, R26.1, U6.60 (PT74B/PROGRAMN); also elsewhere on the board
/iCE_SCK: J20.2, R11.4, U2.6 (CLK), U4.16 (ADBUS0), U5.6 (CLK), U6.59 (PT76A/MCLK/PCLKT0_0)
/iCE_SS_B: J18.2, U4.21 (ADBUS4)
/shield: P1.GND (shield), R1.2
/xFIFO_D0: J1.1, U4.38 (BDBUS0)
/xFIFO_D1: J2.1, U4.39 (BDBUS1)
/xiCE_CRESET: R26.2, U4.24 (ADBUS7)
/~BUTTON: R13.1, SW1.1, U6.27 (PB68A/ADC_CP8)
/~LEDR: D5.C, J29.2, U6.28 (PB68B/ADC_CN8)
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C8.2, C9.2, C10.2, C11.2, C12.2, C13.2, C14.2, C15.2, C16.2, C17.2, C18.2, C19.2, C20.2, C21.2, C22.2, C23.2, C24.2, C25.2, C26.2, C27.2, C28.2, C29.2, C30.2, C31.2, C32.1, C33.1, C34.1, C35.2, C36.2, C37.2, C38.2, C39.2, C40.2, C42.2, C43.2, C44.2, C46.2, C47.2, C48.2, C49.2, C50.2, D1.C, D2.C, J3.11, J3.12, J20.7, J21.5, J21.11, J22.5, J22.11, J23.5, J23.11, J26.2, J27.2, P1.5 (GND), P5.1, R1.1, R7.1, R8.2, R16.2, R18.2, R25.2, R28.2, SW1.2, U1.2 (VSS), U2.4 (GND), U3.3 (GND), U3.8 (GND), U4.1 (GND), U4.5 (GND), U4.10 (AGND), U4.11 (GND), U4.13 (TEST), U4.15 (GND)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; also elsewhere on the board
unnamed: C7.2, R17.2, R18.1, U11.4 (FB)
unnamed: C6.1, C12.1, L2.2, U4.4 (VPHY)
unnamed: C9.1, C13.1, L1.2, U4.9 (VPLL)
unnamed: C41.2, R12.2, R16.1, U10.4 (FB)
unnamed: C45.2, R19.2, R25.1, U12.4 (FB)
unnamed: D2.A, R30.1
unnamed: D5.A, R15.1
unnamed: L3.1, U10.2 (SW)
unnamed: L4.1, U11.2 (SW)
unnamed: L5.1, U12.2 (SW)
unnamed: R2.1, U1.4 (CLK), U4.62 (EECLK)
unnamed: R2.3, U1.5 (CS), U4.63 (EECS)
unnamed: R2.5, R6.2, U1.1 (DO)
unnamed: R2.8, U7.3 (OE/~ST/NC)
unnamed: R6.1, U1.3 (DI), U4.61 (EEDATA)
unnamed: R7.2, U6.50 (JTAG_EN)
unnamed: R8.1, U4.6 (REF)
unnamed: R9.1, U4.14 (~RESET)
unnamed: R10.2, U6.61 (PT74A/INITN)
unnamed: R14.1, U6.19 (PB10A/PCLKT5_2/ADC_CP2/COMP3P)
unnamed: R27.2, R28.1, U6.37 (PB84B/LRC_GPLL0C_IN/VREF3_2)

Notes on the sheet:
We need the FTDI flash. We program a unique serial so multiple iCEBreakers can be used at the same time.
J18: Remove jumper when only programming iCE Replace jumper for programming Flash and for normal operation
FTDI Programmer/UART/FIFO
iCE FPGA Flash
iCE FPGA PSRAM
1v8 I/O
10k or less
Dual PMOD
Note: D0 is inverted
LED/BTN
Single PMOD

Board: 4 copper layers, 50.0 x 37.0 mm, 118 parts (9 on the bottom side), 106 nets.

Other parts of the board:
J28: CRESET; PinHeader_2x01_P2.54mm_Vertical

Their connections:
/iCE_CRESET: J28.1; also elsewhere on the board
GND: J28.2; also elsewhere on the board

## KiCad design projects/gregdavill_boson_sd_hardware_bfgadapter/current_version/working/working.kicad_pcb

File projects/gregdavill_boson_sd_hardware_bfgadapter/current_version/working/readme.md:

# boson_sd_hardware
 
## summary 
* id: gregdavill_boson_sd_hardware_bfgadapter
* user: gregdavill
* name: boson_sd_hardware
* board: bfgadapter
* repo: https://github.com/gregdavill/boson-sd-hardware
* src_file_repo_kicad_pcb: hw/programmerAdapter/bfgAdapter.kicad_pcb
* src_file_repo_kicad_pcb_link: https://github.com/gregdavill/boson-sd-hardware/tree/master/hw/programmerAdapter/bfgAdapter.kicad_pcb

* src_file_repo_sch: hw/programmerAdapter/bfgAdapter.sch
* src_file_repo_sch_link: https://github.com/gregdavill/boson-sd-hardware/tree/master/hw/programmerAdapter/bfgAdapter.sch
* full details link: https://github.com/oomlout/oomlout_oomp_project_bot_v_2/tree/main/projects/gregdavill_boson_sd_hardware_bfgadapter/current_version/working

Parts:
J1: Conn; FTSH-EDGE-20pin
J2: GS3
J4: Prog; PinSocket_1x06_P2.54mm_Vertical

Connections:
+5V: J1.1
/CS: J1.5, J2.1 (G1)
/DI: J1.6, J4.4
/DO: J1.3, J4.1
/GPIOH0: J1.12
/GPIOH1: J1.11
/GPIOH2: J1.14
/GPIOH3: J1.13
/GPIOH4: J1.16
/GPIOH5: J1.15
/GPIOH6: J1.18
/GPIOH7: J1.17
/GPIOH8: J1.20
/GPIOH9: J1.19
/GPIOL0: J1.8, J2.2 (G2), J2.3 (G3), J4.3
/GPIOL1: J1.7
/GPIOL2: J1.10, J4.5
/GPIOL3: J1.9, J4.6
/SK: J1.4, J4.2
GND: J1.2

Notes on the sheet:
~{PWRSAV}
ASYNC Serial (RS232)
ACBUS1
SCK
~{DTR}
ASYNC Bit-bang
SS_n
ACBUS5
ACBUS3
SYNC 245FIFO
ACBUS9
GPIOL1
ACBUS4
GPIOH7
GPIOH9
ADBUS2
ACBUS8
MOSI
~{RDSTB}
~{DSR}
Alternative CS signal selection iCE40 Dev boards use GPIOL0 Instead of the CS MPSSE Line
RXD
ADBUS4
TDO/DI
~{SIWU}
MIOSI3
Pin Name
GPIOL2
SYNC Bit-bang
~{WR}
~{RI}
~{TXE}
MPSSE
ACBUS6
FT1248
ADBUS7
ACBUS7
GPIOH0
~{RTS}
~{WRSTB}

Board: 2 copper layers, 18.4 x 21.0 mm, 3 parts (1 on the bottom side), 7 nets.

## KiCad design projects/gregdavill_boson_sd_hardware_bosonframegrabber/current_version/working/working.kicad_pcb

File projects/gregdavill_boson_sd_hardware_bosonframegrabber/current_version/working/readme.md:

# boson_sd_hardware
 
## summary 
* id: gregdavill_boson_sd_hardware_bosonframegrabber
* user: gregdavill
* name: boson_sd_hardware
* board: bosonframegrabber
* repo: https://github.com/gregdavill/boson-sd-hardware
* src_file_repo_kicad_pcb: hw/bosonFrameGrabber_1_03/bosonFrameGrabber.kicad_pcb
* src_file_repo_kicad_pcb_link: https://github.com/gregdavill/boson-sd-hardware/tree/master/hw/bosonFrameGrabber_1_03/bosonFrameGrabber.kicad_pcb

* src_file_repo_sch: hw/bosonFrameGrabber_1_03/bosonFrameGrabber.sch
* src_file_repo_sch_link: https://github.com/gregdavill/boson-sd-hardware/tree/master/hw/bosonFrameGrabber_1_03/bosonFrameGrabber.sch
* full details link: https://github.com/oomlout/oomlout_oomp_project_bot_v_2/tree/main/projects/gregdavill_boson_sd_hardware_bosonframegrabber/current_version/working

Board: 4 copper layers, 63.0 x 63.0 mm, 64 parts (15 on the bottom side), 93 nets.

Parts:
C1, C2: 100pF; C_0402
C3, C4, C8: 1uF; C_0402
C5, C9, C10, C11, C12, C14, C15, C16, C17, C18, C19, C20, C21, C22: 100nF; C_0402
C6, C7, C13: 10uF; C_0603
C23: C; C_0603
C24: 1uF; C_0603
D1: LED; LED_0402
D2: D_TVS_x2_AAC; SOT-23
D3: D_Schottky_ALT; D_SOD-123F
J1, J2: JST GH Series; JST_GH_BM06B-GHS-TBT_06x1.25mm_Straight
J4: MicroSD; 1040310811
J5: SlimStack_12P; Molex_SlimStack-502430-1410_2x07_P0.4mm_Vertical
L1: L; L_0603
R1, R2: 100R; R_0402
R3, R16, R17, R18: R; R_0402
R4: 10k; R_0402
R5: R; R_0603
R6: 5.1K; R_0603
R7, R8, R12, R13: 220R; R_0402
R9, R10, R14, R15: 47R; R_0402
R11: 1K; R_0402
SW1, SW2, SW3: SW_Push; SW_SPST_EVQP0
U1, U8, U9: TLV733P; X2SON
U2, U7: SN74LVC1T45; SOT-666
U3: ECP5U25; csBGA_132
U4: S27KS0641; BGA_24
U5: Boson; DF40_80Pin
U6: AT25SF081; DFN-8-1EP_3x2mm_Pitch0.5mm
U10: AP3012; SOT-23-5
X1: ASDMB; Oscillator_SMD_SeikoEpson_SG210-4pin_2.5x2.0mm

Connections:
16MHZ_IN: U3.L19, X1.3
+1V1: C8.1, C10.1, C14.1, C17.1, C18.1, C20.1, U3.H8, U3.H9, U3.H10, U3.H11, U3.H12, U3.H13, U3.J8, U3.J13, U3.K8, U3.K13, U3.L8, U3.L13, U3.M8, U3.M13, U3.N8, U3.N9, U3.N10, U3.N11, U3.N12, U3.N13, U9.1
+1V8: C4.1, C9.1, C12.1, C16.1, J5.4, R11.2, R16.2, R17.2, R18.2, U2.1, U3.F11, U3.F12, U3.H6, U3.H7, U3.H14, U3.H15, U3.J6, U3.J15, U3.L6, U3.L7, U3.L14, U3.L15, U3.M6, U3.M15, U4.B4, U4.D1, U4.E4, U7.1, U8.1, X1.1, X1.4
+2V5: C3.1, C5.1, C11.1, C15.1, U1.1, U3.F6, U3.F15, U3.P6, U3.P15
+3V3: C6.1, C7.1, C13.1, C19.1, C21.1, C22.1, J1.1, J2.1, J4.4, J5.2, R4.1, U1.3, U1.4, U2.6, U3.F9, U3.F10, U3.P9, U3.P10, U3.R4, U5.2, U5.4, U5.6, U5.8, U6.8, U7.6, U8.3, U8.4, U9.3, U9.4
/sheetOLED/CLK_N: J5.3, R13.1, R15.1
/sheetOLED/CLK_P: J5.1, R12.1, R14.1
/sheetOLED/D_N: J5.9, R8.1, R10.1, R11.1
/sheetOLED/D_P: J5.7, R7.1, R9.1
BOSON_CK: U3.B12, U5.55
BOSON_DATA0: U3.A18, U5.77
BOSON_DATA1: U3.A17, U5.62
BOSON_DATA2: U3.A14, U5.51
BOSON_DATA3: U3.B13, U5.56
BOSON_DATA4: U3.C12, U5.27
BOSON_DATA5: U3.D16, U5.28
BOSON_DATA6: U3.D13, U5.32
BOSON_DATA7: U3.E15, U5.31
BOSON_DATA8: U3.D11, U5.25
BOSON_DATA9: U3.C15, U5.46
BOSON_DATA10: U3.C14, U5.45
BOSON_DATA11: U3.B15, U5.48
BOSON_DATA12: U3.B16, U5.47
BOSON_DATA13: U3.C13, U5.41
BOSON_DATA14: U3.E11, U5.21
BOSON_DATA15: U3.C16, U5.38
BOSON_DATA_EN: U3.B17, U5.78
BOSON_EXTSYNC: U3.B18, U5.72
BOSON_HSYNC: U3.A19, U5.73
BOSON_RESET: U3.B20, U5.24
BOSON_RXD: U3.B19, U5.33
BOSON_TXD: U3.D14, U5.43
BOSON_VSYNC: U3.A13, U5.53
BUTTON_A: R16.1, SW1.1, U3.P20
BUTTON_B: R17.1, SW2.1, U3.P18
BUTTON_C: R18.1, SW3.1, U3.N20
CLKN: R13.2, U3.F1
CLKN_BIAS: R15.2, U3.L5
CLKP: R12.2, U3.G2
CLKP_BIAS: R14.2, U3.J5
DATAN: R8.2, U3.J1
DATAN_BIAS: R10.2, U3.M4
DATAP: R7.2, U3.K2
DATAP_BIAS: R9.2, U3.L4
FPGA_RESET: R4.2, U3.R2, U3.W3
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, C13.2, C14.2, C15.2, C16.2, C17.2, C18.2, C19.2, C20.2, C21.2, C22.2, C23.2, C24.2, D2.3, J1.2, J1.4, J1.6, J2.6, J4.6, J4.9, J4.10, J5.5, J5.11, J5.12, J5.13, R3.1, R6.2, SW1.2, SW2.2, SW3.2, U1.2, U2.2, U3.B7, U3.B14, U3.C19, U3.D4, U3.F7, U3.F8, U3.F13, U3.F14, U3.G4, U3.G6, U3.G7, U3.G8, U3.G9, U3.G10, U3.G11, U3.G12, U3.G13, U3.G14, U3.G15, U3.G17, U3.H19, U3.J2, U3.J7, U3.J9, U3.J10, U3.J11, U3.J12, U3.J14, U3.K6, U3.K7, U3.K9, U3.K10, U3.K11, U3.K12, U3.K14, U3.K15, U3.L9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
HYPERBUS_CK: U3.D20, U4.B2
HYPERBUS_CK#: U3.D19, U4.B1
HYPERBUS_CS#: U3.C18, U4.A3
HYPERBUS_DQ0: U3.G19, U4.D3
HYPERBUS_DQ1: U3.G20, U4.D2
HYPERBUS_DQ2: U3.E19, U4.C4
HYPERBUS_DQ3: U3.J19, U4.D4
HYPERBUS_DQ4: U3.J20, U4.D5
HYPERBUS_DQ5: U3.K19, U4.E3
HYPERBUS_DQ6: U3.K20, U4.E2
HYPERBUS_DQ7: U3.J18, U4.E1
HYPERBUS_RESET#: U3.C20, U4.A4
HYPERBUS_RWDS: U3.F20, U4.C3
IO_A: D2.2, J1.5, R1.1
IO_A_DIR: U2.5, U3.P2
IO_A_INTERNAL: U2.3, U3.N1
IO_B: D2.1, J1.3, R2.1
IO_B_DIR: U3.P3, U7.5
IO_B_INTERNAL: U3.P1, U7.3
JTAG_TCK: J2.3, U3.T5
JTAG_TDI: J2.4, U3.R5
JTAG_TDO: J2.5, U3.V4
JTAG_TMS: J2.2, U3.U5
LCD_LED: C24.1, D3.1, J5.10, R5.1
LCD_LED_EN: U3.B1, U10.4
LCD_RESET: J5.8, U3.L1
LCD_SYNC: J5.6, U3.L2
LED_A: D1.2, U3.M1
unnamed: C1.1, R1.2, U2.4
unnamed: C2.1, R2.2, U7.4
unnamed: C23.1, L1.1, U10.5
unnamed: D1.1, R3.2
unnamed: D3.2, L1.2, U10.1
unnamed: R5.2, R6.1, U10.3
QSPI_D2: U3.V2, U6.3
QSPI_D3: U3.W1, U6.7
SD_CD: J4.11, U3.A7
SD_CK: J4.5, U3.A10
SD_CMD: J4.3, U3.A9
SD_DAT0: J4.7, U3.B11
SD_DAT1: J4.8, U3.A11
SD_DAT2: J4.1, U3.A8
SD_DAT3: J4.2, U3.B9
SPI_CONFIG_MISO: U3.Y2, U6.2
SPI_CONFIG_MOSI: U3.W2, U6.5
SPI_CONFIG_SCK: U3.U3, U6.6
SPI_CONFIG_SS: U3.T2, U6.1

Notices in the files:
projects/gregdavill_arctickoala_arctic_koala/current_version/working/working.kicad_pcb:
(C) 2019 Greg Davill
License: CC-BY-SA 4.0
GsD (C) 2019
CC-BY-SA 4.0
projects/gregdavill_boson_sd_hardware_bfgadapter/current_version/working/working.kicad_pcb:
CC-BY-SA
