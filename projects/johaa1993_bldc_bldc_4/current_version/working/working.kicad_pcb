# Repository oomlout/oomlout_oomp_project_bot_v_2 (continued)

## KiCad design projects/johaa1993_pdb_pca9698/current_version/working/working.kicad_pcb (continued)

Board: 4 copper layers, 76.2 x 71.1 mm, 13 parts (8 on the bottom side), 51 nets.

## KiCad design projects/johaa1993_pdb_pdb1/current_version/working/working.kicad_pcb

File projects/johaa1993_pdb_pdb1/current_version/working/readme.md:

# pdb
 
## summary 
* id: johaa1993_pdb_pdb1
* user: johaa1993
* name: pdb
* board: pdb1
* repo: https://github.com/johaa1993/PDB
* src_file_repo_kicad_pcb: pdb4/pdb1.kicad_pcb
* src_file_repo_kicad_pcb_link: https://github.com/johaa1993/PDB/tree/master/pdb4/pdb1.kicad_pcb

* src_file_repo_sch: PCA9698/PCA9698.sch
* src_file_repo_sch_link: https://github.com/johaa1993/PDB/tree/master/PCA9698/PCA9698.sch
* full details link: https://github.com/oomlout/oomlout_oomp_project_bot_v_2/tree/main/projects/johaa1993_pdb_pdb1/current_version/working

Board: 4 copper layers, 49 parts (4 on the bottom side), 31 nets, no tracks yet.

Parts:
C1, C4: CP; c_elec_4x4.5
C2, C3, C5, C6: C; C_0805
D1, D2, D3, D4: LED; LED_0805
F1, F2: FUSE; Fuseholder_test
P1: CONN_XT60_Male; CONN_XT60_Male1_Horizontal
P2, P3, P10, P11: CONN_02X06; Pin_Header_Straight_2x06
P4, P7: CONN_XT60_Female; CONN_XT60_Female_Horizontal
P5, P6, P8, P9: CONN_01X03; Pin_Header_Straight_1x03
Q1, Q2: BUK9Y4R8-60E; SOT-669_LFPAK
R1, R2, R3, R4, R5, R7, R8, R9, R10, R11, R12, R14: R; R_0805
R6, R13: R; SMD_1052_Metric
U1, U4, U6, U9: NSI45020AT1G; SOD-123
U2, U7: 74LVC1G08; SOT-353
U3, U8: MIC5014; SOIC-8_3.9x4.9mm_Pitch1.27mm
U5, U10: INA169; SOT-23-5

Connections:
/Current_Feedback0: C3.1, P10.3, R7.1, U5.1
/Current_Feedback1: C6.1, P10.5, R14.1, U10.1
/Enable_MCU0: P6.3, P11.3
/Enable_MCU1: P9.3, P11.5
/Enabled_Fuse0: P3.3, R1.1
/Enabled_Fuse1: P3.5, R8.1
/Enabled_SW0: P2.3, R5.1
/Enabled_SW1: P2.5, R12.1
/channel0/3.3V: P5.1, P6.1, U2.5
/channel0/Enable_Reed: P5.3, P8.3
/channel0/Power: C2.1, C5.1, P1.2, R6.2, R13.2, U5.3, U5.5, U10.3, U10.5
/channel0/fuse/in+: F1.1, R6.1, U5.4
/channel0/kill_sw/in+: C1.1, F1.2, Q1.5, U1.2, U3.1
/channel0/kill_sw/out+: P4.2, Q1.1, Q1.2, Q1.3, U3.3, U4.2
/channel1/3.3V: P8.1, P9.1, U7.5
/channel1/fuse/in+: F2.1, R13.1, U10.4
/channel1/kill_sw/in+: C4.1, F2.2, Q2.5, U6.2, U8.1
/channel1/kill_sw/out+: P7.2, Q2.1, Q2.2, Q2.3, U8.3, U9.2
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, D1.1, D2.1, D3.1, D4.1, P1.1, P2.1, P3.1, P4.1, P7.1, P10.1, P11.1, R2.2, R3.2, R4.2, R7.2, R9.2, R10.2, R11.2, R14.2, U2.3, U3.4, U5.2, U7.3, U8.4, U10.2
unnamed: D1.2, R1.2, U1.1
unnamed: D2.2, R5.2, U4.1
unnamed: D3.2, R8.2, U6.1
unnamed: D4.2, R12.2, U9.1
unnamed: P5.2, R3.1, U2.1
unnamed: P6.2, R2.1, U2.2
unnamed: P8.2, R10.1, U7.1
unnamed: P9.2, R9.1, U7.2
unnamed: Q1.4, U3.5
unnamed: Q2.4, U8.5
unnamed: R4.1, U2.4, U3.2
unnamed: R11.1, U7.4, U8.2
