# Repository oomlout/oomlout_oomp_project_bot_v_2

## KiCad design projects/johaa1993_bldc_bldc_4/current_version/working/working.kicad_pcb

File projects/johaa1993_bldc_bldc_4/current_version/working/readme.md:

# bldc
 
## summary 
* id: johaa1993_bldc_bldc_4
* user: johaa1993
* name: bldc
* board: bldc_4
* repo: https://github.com/johaa1993/bldc
* src_file_repo_kicad_pcb: design/BLDC_4.kicad_pcb
* src_file_repo_kicad_pcb_link: https://github.com/johaa1993/bldc/tree/master/design/BLDC_4.kicad_pcb

* src_file_repo_sch: design/BLDC_4.sch
* src_file_repo_sch_link: https://github.com/johaa1993/bldc/tree/master/design/BLDC_4.sch
* full details link: https://github.com/oomlout/oomlout_oomp_project_bot_v_2/tree/main/projects/johaa1993_bldc_bldc_4/current_version/working

Board: 4 copper layers, 38.5 x 65.0 mm, 128 parts (71 on the bottom side), 96 nets.

Parts:
1PIN, 1PIN#2, 1PIN#3, 1PIN#4: P***; 1pin
C1, C8, C9, C39, C40, C43, C44, C49: 10u,50V; SMD-1206
C2, C3, C27, C32: 100n; SMD-0603_c
C4, C5, C6, C7: 4n7; SMD-0603_c
C10, C11, C12, C13, C14, C16, C17, C24, C31, C35: 2.2u; SMD-0603_c
C15, C38: 15p; SMD-0603_c
C18: 2.2u; SMD-0805
C19: 120p; SMD-0603_c
C20, C52: 1u; SMD-0603_c
C21: 6.8n; SMD-0603_c
C22: 22n; SMD-0603_c
C23: 1u; SMD-0805
C25, C33: 100u; c_tant_B
C26: 15n; SMD-0603_c
C28, C29, C30: 220n; SMD-0805
C34, C36: 2.2n; SMD-0603_c
C37: 15u,100V; c_2220
C51: 15u, 100v; c_2220
C301: 100nF; SMD-0402
C401: 1u; SMD-0603
D1: GREEN; LED-0603
D2: RED; LED-0603
D3: LED; LED-0603
D4: DIODESCH; Diode-SMA_Handsoldering
K1: SERVO; pinhead-1X03
L1: 22u; inductor_smd_8x5mm
P1: HALL/Encoder; MICRO_JST_6
P2: SWD; MICRO_JST_6
P3: PWR_COMM; MICRO_JST_6
P4: IN+; 1PAD_4x5mm
P5: IN-; 1PAD_4x5mm
P6: MOTOR1; 1PAD_4x5mm
P7: MOTOR2; 1PAD_4x5mm
P9: MOTOR3; 1PAD_4x5mm
P101: CANBUS; b4b-ph-kl
Q1, Q2, Q3, Q4, Q5, Q6: IRFS3006; D2PAK-7-GDS
R3, R23, R26, R30, R32, R36, R46: 33k; SMD-0603_r
R4, R5, R11, R12, R13, R22, R24, R27, R33: 2k2; SMD-0603_r
R6: 0R; SMD-0603_r
R7, R8, R9, R10, R16, R20, R101, R102, R402: 10k; SMD-0603_r
R15: 330k; SMD-0603_r
R17: 18k; SMD-0603_r
R18: 3k3; SMD-0603_r
R19: 15k; SMD-0603_r
R21: 220k; SMD-0603_r
R25: 1M; SMD-0603_r
R28, R29, R34, R35, R42, R43: 4R7; SMD-0603_r
R37, R38, R48, R49, R50, R51: 100R; SMD-0603_r
R53, R54: SHUNT; WSLP2726
R103, R104: 22R; SMD-0603_r
R401: NI; SMD-0603_r
U1: STM32F40X_LQFP64; lqfp64_pad_mod
U2: NCP1117ST33T3G; SOT-223
U3: DRV8302; TSSOP-56-PP
U301: LM73; SOT-23-6
U401: SN65HVD232; SOIC-8-W
X1: MINI-USB-SHIELD-32005-201; USB-UX60R-MB-5ST
X2: 8MHz 10ppm; Crystal_5x3mm

Connections:
+5V: C33.1, K1.2, L1.2, P1.1, P3.6, P101.4, R6.2, R17.1, U2.3
/CAN bus transceiver/CANH: P101.3, R401.1, U401.7
/CAN bus transceiver/CANL: P101.2, R401.2, U401.6
/CAN bus transceiver/CAN_RX: U1.61, U401.4
/CAN bus transceiver/CAN_TX: U1.62, U401.1
/Filters/HALL1_IN: P1.3, R8.1, R13.1
/Filters/HALL1_OUT: C7.1, R8.2, U1.58
/Filters/HALL2_IN: P1.4, R9.1, R12.1
/Filters/HALL2_OUT: C6.1, R9.2, U1.59
/Filters/HALL3_IN: P1.5, R10.1, R11.1
/Filters/HALL3_OUT: C5.1, R10.2, U1.52
/Filters/TEMP_IN: C4.2, P1.2, R7.1, U1.8
/I²C temp sensor/SDA: P3.2, R101.2, U1.30, U1.37, U301.6
/MCU/ADC_EXT: P3.3, U1.25
/MCU/AN_IN: C2.2, R3.2, R4.2, U1.10
/MCU/BR_SO1: U1.22, U3.25
/MCU/BR_SO2: U1.21, U3.26
/MCU/DC_CAL: U1.33, U3.12
/MCU/EN_GATE: U1.51, U3.16
/MCU/FAULT: U1.53, U3.6
/MCU/H1: U1.43, U3.17
/MCU/H2: U1.42, U3.19
/MCU/H3: U1.41, U3.21
/MCU/L1: U1.36, U3.18
/MCU/L2: U1.35, U3.20
/MCU/L3: U1.34, U3.22
/MCU/LED_GREEN: R37.2, U1.24
/MCU/LED_RED: R38.2, U1.23
/MCU/RX_SCL: P3.1, R102.2, U1.29, U1.38, U301.4
/MCU/SENS1: R23.2, R24.2, U1.16
/MCU/SENS2: R26.2, R27.2, U1.15
/MCU/SENS3: R32.2, R33.2, U1.14
/MCU/SERVO: C3.2, R5.1, U1.57
/MCU/USB_DM: R103.1, U1.44
/MCU/USB_DP: R104.1, U1.45
/Mosfet driver/H1_LOW: Q2.S, R30.1, R36.1, R53.2, U3.44
/Mosfet driver/H1_VS: C28.1, P9.1, Q1.S, Q2.D, R32.1, U3.46
/Mosfet driver/H2_VS: C29.1, P7.1, Q3.S, Q4.D, R26.1, U3.41
/Mosfet driver/H3_LOW: Q6.S, R46.1, R54.1, U3.34
/Mosfet driver/H3_VS: C30.1, P6.1, Q5.S, Q6.D, R23.1, U3.36
/Mosfet driver/M_H1: R28.2, U3.47
/Mosfet driver/M_H2: R34.2, U3.42
/Mosfet driver/M_H3: R42.2, U3.37
/Mosfet driver/M_L1: R29.2, R30.2, U3.45
/Mosfet driver/M_L2: R35.2, U3.40
/Mosfet driver/M_L3: R43.2, U3.35
/Mosfet driver/SH1_A: R48.1, R54.3
/Mosfet driver/SH1_B: R49.1, R54.4
/Mosfet driver/SH2_A: R50.1, R53.4
/Mosfet driver/SH2_B: R51.1, R53.3
GND: C1.1, C2.1, C3.1, C4.1, C5.2, C6.2, C7.2, C8.1, C9.1, C10.1, C11.1, C12.1, C13.1, C14.1, C15.2, C16.2, C17.2, C18.2, C19.1, C20.1, C21.1, C23.1, C24.2, C25.2, C26.1, C31.1, C32.1, C33.2, C35.1, C37.1, C38.2, C39.1, C40.1, C43.2, C44.2, C49.2, C51.1, C52.1, C301.2, C401.2, D1.2, D2.2, D3.2, D4.1, K1.3, P1.6, P2.3, P3.4, P5.1, P101.1, Q4.S, R4.1, R16.2, R18.2, R20.2, R21.1, R24.1, R25.1, R27.1, R33.1, R53.1, R54.2, R402.2, U1.12, U1.18, U1.60, U1.63, U2.1, U3.8, U3.10, U3.28, U3.39, U3.57, U301.2, U401.2, X1.5, X2.3
NRST: C32.2, P2.5, U1.7
unnamed: C15.1, U1.5, X2.1
unnamed: C16.1, U1.31
unnamed: C17.1, U1.47
unnamed: C18.1, U3.13
unnamed: C19.2, R19.2, U3.2
unnamed: C20.2, C52.2, R15.1, U3.23
unnamed: C21.2, R19.1
unnamed: C22.1, U3.14
unnamed: C22.2, U3.15
unnamed: C23.2, U3.27
unnamed: C26.2, U3.56
unnamed: C27.1, D4.2, L1.1, U3.50, U3.51
unnamed: C27.2, U3.52
unnamed: C28.2, U3.48
unnamed: C29.2, U3.43
unnamed: C30.2, U3.38
unnamed: C34.1, R48.2, U3.33
unnamed: C34.2, R49.2, U3.32
unnamed: C36.1, R50.2, U3.31
unnamed: C36.2, R51.2, U3.30
unnamed: C38.1, U1.6, X2.2
unnamed: D1.1, R37.1
unnamed: D2.1, R38.1
unnamed: D3.1, R22.1
unnamed: K1.1, R5.2
unnamed: Q1.G, R28.1
unnamed: Q2.G, R29.1
unnamed: Q3.G, R34.1
unnamed: Q4.G, R35.1, R36.2
unnamed: Q5.G, R42.1
unnamed: Q6.G, R43.1, R46.2
unnamed: R6.1, X1.1
unnamed: R15.2, R16.1, U3.11
unnamed: R17.2, R18.1, U3.3
unnamed: R20.1, U3.7
unnamed: R21.2, U3.1
unnamed: R25.2, U3.49
unnamed: R103.2, X1.2
unnamed: R104.2, X1.3
unnamed: R402.1, U401.8
SWCLK: P2.2, U1.49
SWDIO: P2.4, U1.46
VCC: C10.2, C11.2, C12.2, C13.2, C14.2, C24.1, C25.1, C31.2, C35.2, C301.1, C401.1, P2.1, P3.5, R7.2, R11.2, R12.2, R13.2, R22.2, R101.1, R102.1, U1.1, U1.13, U1.19, U1.32, U1.48, U1.64, U2.2, U3.9, U3.24, U301.3, U401.3
V_SUPPLY: C1.2, C8.2, C9.2, C37.2, C39.2, C40.2, C43.1, C44.1, C49.1, C51.2, P4.1, Q1.D, Q3.D, Q5.D, R3.1, U3.29, U3.53, U3.54

## KiCad design projects/johaa1993_evbms_6802_2slv/current_version/working/working.kicad_pcb

File projects/johaa1993_evbms_6802_2slv/current_version/working/readme.md:

# evbms
 
## summary 
* id: johaa1993_evbms_6802_2slv
* user: johaa1993
* name: evbms
* board: 6802_2slv
* repo: https://github.com/johaa1993/evBMS
* src_file_repo_kicad_pcb: 6802Slave/6802-2slv.kicad_pcb
* src_file_repo_kicad_pcb_link: https://github.com/johaa1993/evBMS/tree/master/6802Slave/6802-2slv.kicad_pcb

* src_file_repo_sch: 6802Slave/6802-2slv.sch
* src_file_repo_sch_link: https://github.com/johaa1993/evBMS/tree/master/6802Slave/6802-2slv.sch
* full details link: https://github.com/oomlout/oomlout_oomp_project_bot_v_2/tree/main/projects/johaa1993_evbms_6802_2slv/current_version/working

Parts:
C1, C2, C3, C4, C5, C6, C7, C8, C9, C10, C11, C12, C13, C17, C19, C20: 100nf
C14, C15, C16, C18, C21, C22, C23, C24, C25: 1uf
D1: BI_LED
D2: 1N4148
J1: DB15
J2: USB B conn.
J3: USB A connector
J4: ICSP
P1: CONN_1
R1, R2, R3, R4, R5, R6, R7, R8, R9, R10, R11, R12: 100R
R13: 20R
R14, R15, R29, R30: 200K
R16: 4K7
R17: 1K
R18: 680R
R19, R20, R22, R23: 845R
R21, R25, R26, R27, R28: 330R
R24: 10K
U1: LTC6802-2
U2: TCLT1009
U3: ACPL-W61L
U4: ACPL-K64L
U5: PIC16F1825
U6: MAX232

Connections:
GND: C19.2, C20.1, C23.2, C25.1, D1.2 (K), J2.4, J3.4, J4.3, U2.2 (K), U3.4 (GND), U5.14 (VSS), U6.15 (GND)
GNDPWR: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, C13.2, C14.2, C15.2, C16.1, C17.2, C18.2, J1.7, P1.1, U1.26 (V-), U1.27 (NC), U1.37 (A0), U1.38 (A1), U1.39 (A2), U1.40 (A3), U2.3 (E), U4.5 (GND)
unnamed: R16.1, U1.44 (CSBI), U2.4 (C)
unnamed: C13.1, R13.2, U1.1 (V+)
unnamed: C6.1, R6.2, U1.14 (C6)
unnamed: C22.2, U6.1 (C1+)
unnamed: C22.1, U6.3 (C1-)
unnamed: C24.2, U6.4 (C2+)
unnamed: C24.1, U6.5 (C2-)
unnamed: C25.2, U6.6 (V-)
unnamed: J1.1, R12.1, R13.1
unnamed: C8.1, R8.2, U1.10 (C8)
unnamed: C12.1, R12.2, U1.2 (C12)
unnamed: C11.1, R11.2, U1.4 (C11)
unnamed: C2.1, R2.2, U1.22 (C2)
unnamed: C1.1, R1.2, U1.24 (C1)
unnamed: C10.1, R10.2, U1.6 (C10)
unnamed: C9.1, R9.2, U1.8 (C9)
unnamed: C5.1, R5.2, U1.16 (C5)
unnamed: J1.4, R6.1
unnamed: C4.1, R4.2, U1.18 (C4)
unnamed: J1.11 (P111), R7.1
unnamed: C7.1, R7.2, U1.12 (C7)
unnamed: J1.14, R1.1
unnamed: J1.6, R2.1
unnamed: J1.13, R3.1
unnamed: J1.5, R4.1
unnamed: D2.2 (K), J2.3, J3.3
unnamed: J1.2, R10.1
unnamed: J1.10, R9.1
unnamed: J1.3, R8.1
unnamed: D1.1 (A1), R25.1
unnamed: D1.3 (A2), R26.1
unnamed: J1.9, R11.1
unnamed: J3.2, U6.14 (T1OUT)
unnamed: J4.4, R27.2
unnamed: R27.1, U5.13 (ICSPDAT)
unnamed: R28.1, U5.12 (ICSPCLK)
unnamed: J4.5, R28.2
unnamed: J1.12, R5.1
unnamed: U5.6 (RC4/TX), U6.10 (T2IN)
unnamed: U5.7 (RC3), U6.11 (T1IN)
unnamed: U5.5 (RC5/RX), U6.12 (R1OUT)
unnamed: R23.2, U5.10 (SCK/RC0)
unnamed: D2.1 (A), U6.7 (T2OUT)
unnamed: J2.2, U6.13 (R1IN)
unnamed: C21.1, U6.2 (V+)
unnamed: R21.1, U5.11 (SS/RA2)
unnamed: R26.2, U5.3 (RA4)
unnamed: R25.2, U5.2 (RA5)
unnamed: J4.1, R24.1, U5.4 (RA3/MCLR)
unnamed: R18.2, U1.43 (SDO)
unnamed: R17.1, U3.1 (A)
unnamed: R18.1, U3.3 (K)
unnamed: U1.41 (SCKI), U4.7 (Vo1)
unnamed: U1.42 (SDI), U4.6 (Vo2)
unnamed: U3.5 (Vo), U5.9 (SDI/RC1)
unnamed: R22.2, U4.1 (A1)
unnamed: R19.2, U4.4 (A2)
unnamed: R20.1, U4.3 (K2)
unnamed: R20.2, U5.8 (SDO/RC2)
unnamed: R23.1, U4.2 (K1)
unnamed: R21.2, U2.1 (A)
unnamed: C14.1, J1.15, R14.2, R29.2, U1.28 (Vtemp1)
unnamed: C18.1, R14.1, R15.1, R29.1, R30.1, U1.30 (Vref)
unnamed: C3.1, R3.2, U1.20 (C3)
unnamed: C15.1, J1.8, R15.2, R30.2, U1.29 (Vtemp2)
unnamed: C19.1, C20.2, C21.2, C23.1, J2.1, J3.1, J4.2, R19.1, R22.1, R24.2, U3.6 (Vdd), U5.1 (VDD), U6.16 (VCC)
unnamed: C16.2, C17.1, R16.2, R17.2, U1.31 (Vreg), U1.32 (TOS), U1.33 (MMB), U4.8 (Vdd)
unnamed: J2.5 (Shield), J2.6 (Shield), J3.5 (Shield), J3.6 (Shield)

Notes on the sheet:
Connect to 100K thermistors (tempco -4%/C) or use diodes (2.2mv/C)
LTC6802 powered from cells. Allowable range 10 - 60 volts 4 - 12 cells.
Standard USB connectors used for bus in and out connections. This allows the use of off the shelf cables for master-slave and slave-slave connections. NOTE: this is not a USB compatible connection. MAX232 used to shift ttl bus signals to RS232 levels. D3 prevents U7 from pulling master bus negative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
Slave bus out
Bus In
Input filters
Slave bus in
Bus Out
For temperature sensor 1 on J1-pin15, omit R29 when using diodes. If using thermistor, add R29 to circuit. For temperature sensor 2 on J1-pin8, omit R30 when using diodes. If using thermistor, add R30 to circuit.
Connect 2nd wire from temperature sensors to Cell 1 negative in battery box.
Master bus out

Board: 2 copper layers, 68 parts (0 on the bottom side), 70 nets.

## KiCad design projects/johaa1993_kicad_ltc6802_2_main/current_version/working/working.kicad_pcb

File projects/johaa1993_kicad_ltc6802_2_main/current_version/working/readme.md:

# kicad_ltc6802_2
 
## summary 
* id: johaa1993_kicad_ltc6802_2_main
* user: johaa1993
* name: kicad_ltc6802_2
* board: main
* repo: https://github.com/johaa1993/KiCad-LTC6802-2
* src_file_repo_kicad_pcb: main/main.kicad_pcb
* src_file_repo_kicad_pcb_link: https://github.com/johaa1993/KiCad-LTC6802-2/tree/master/main/main.kicad_pcb

* src_file_repo_sch: main/main.sch
* src_file_repo_sch_link: https://github.com/johaa1993/KiCad-LTC6802-2/tree/master/main/main.sch
* full details link: https://github.com/oomlout/oomlout_oomp_project_bot_v_2/tree/main/projects/johaa1993_kicad_ltc6802_2_main/current_version/working

Parts:
C1, C2: C; C_0805
P1: CONN_01X13; Pin_Header_Straight_1x13
P2, P3: CONN_01X04; Pin_Header_Straight_1x04
P4: CONN_01X06; Pin_Header_Straight_1x06
R1, R2: R; R_0805
U1: LTC6802-2; SSOP-44

Connections:
+5V: C2.1, R1.2, R2.2, U1.31 (Vreg_5V), U1.33 (MMB)
GND: C1.1, C2.2, P1.1, P2.1, P3.1, P4.1, U1.26 (V-)
unnamed: C1.2, P2.4, U1.30 (Vref_3.1V)
unnamed: P1.2, U1.24 (C1)
unnamed: P1.3, U1.22 (C2)
unnamed: P1.4, U1.20 (C3)
unnamed: P1.5, U1.18 (C4)
unnamed: P1.6, U1.16 (C5)
unnamed: P1.7, U1.14 (C6)
unnamed: P1.8, U1.12 (C7)
unnamed: P1.9, U1.10 (C8)
unnamed: P1.10, U1.8 (C9)
unnamed: P1.11, U1.6 (C10)
unnamed: P1.12, U1.4 (C11)
unnamed: P1.13, U1.1 (V+), U1.2 (C12)
unnamed: P2.2, U1.28 (Vtemp1)
unnamed: P2.3, U1.29 (Vtemp2)
unnamed: P3.3, U1.35 (GPIO1)
unnamed: P3.4, U1.36 (GPIO2)
unnamed: P4.3, U1.44 (CSBI)
unnamed: P4.4, R1.1, U1.43 (SDO)
unnamed: P4.5, R2.1, U1.42 (SDI)
unnamed: P4.6, U1.41 (SCKI)

Board: 2 copper layers, 50.8 x 40.6 mm, 9 parts (4 on the bottom side), 23 nets.

## KiCad design projects/johaa1993_kicad_power_board_kicad_power_board/current_version/working/working.kicad_pcb

File projects/johaa1993_kicad_power_board_kicad_power_board/current_version/working/readme.md:

# kicad_power_board
 
## summary 
* id: johaa1993_kicad_power_board_kicad_power_board
* user: johaa1993
* name: kicad_power_board
* board: kicad_power_board
* repo: https://github.com/johaa1993/KiCad-Power_Board
* src_file_repo_kicad_pcb: KiCad-Power_Board.kicad_pcb
* src_file_repo_kicad_pcb_link: https://github.com/johaa1993/KiCad-Power_Board/tree/master/KiCad-Power_Board.kicad_pcb

* src_file_repo_sch: KiCad-Power_Board.sch
* src_file_repo_sch_link: https://github.com/johaa1993/KiCad-Power_Board/tree/master/KiCad-Power_Board.sch
* full details link: https://github.com/oomlout/oomlout_oomp_project_bot_v_2/tree/main/projects/johaa1993_kicad_power_board_kicad_power_board/current_version/working

Board: 2 copper layers, 121.9 x 61.0 mm, 26 parts (0 on the bottom side), 14 nets.

Parts:
D1, D2, D3, D4: LED; LED_0402
F1, F2, F3, F4: FUSE; Fuseholder5x20_horiz_open_lateral_Type-II
I1: ACS758; ACS758-hall
P1, P4, P7, P10: Batt; XT60
P2: PWR_Status; Pin_Header_Straight_1x06
P3, P6, P9, P12: Out; XT60
U1, U2, U3, U4: LM3480-3.3; SOT-23
U5, U6, U7, U8: ACS758; ACS758_Vertical

Connections:
+BATT: F1.1, F2.1, F3.1, F4.1, P1.2, P4.2, P7.2, P10.2
/pwr_module1/PWR_3.3V_Status: D2.2, P2.1, U2.1
/pwr_module2/PWR_3.3V_Status: D1.2, P2.2, U1.1
/pwr_module3/PWR_3.3V_Status: D4.2, P2.3, U4.1
/pwr_module4/PWR_3.3V_Status: D3.2, P2.4, U3.1
GND: D1.1, D2.1, D3.1, D4.1, P1.1, P3.1, P4.1, P6.1, P7.1, P9.1, P10.1, P12.1, U1.3, U2.3, U3.3, U4.3
unnamed: F1.2, U1.2, U5.4
unnamed: F2.2, U2.2, U6.4
unnamed: F3.2, U3.2, U7.4
unnamed: F4.2, U4.2, U8.4
unnamed: P3.2, U5.5
unnamed: P6.2, U6.5
unnamed: P9.2, U7.5
unnamed: P12.2, U8.5

## KiCad design projects/johaa1993_pdb_main/current_version/working/working.kicad_pcb

File projects/johaa1993_pdb_main/current_version/working/readme.md:

# pdb
 
## summary 
* id: johaa1993_pdb_main
* user: johaa1993
* name: pdb
* board: main
* repo: https://github.com/johaa1993/PDB
* src_file_repo_kicad_pcb: sw_low_side/main.kicad_pcb
* src_file_repo_kicad_pcb_link: https://github.com/johaa1993/PDB/tree/master/sw_low_side/main.kicad_pcb

* src_file_repo_sch: sw_low_side/main.sch
* src_file_repo_sch_link: https://github.com/johaa1993/PDB/tree/master/sw_low_side/main.sch
* full details link: https://github.com/oomlout/oomlout_oomp_project_bot_v_2/tree/main/projects/johaa1993_pdb_main/current_version/working

Parts:
D1: LED; LED_0805
P1, P2: CONN_XT60; XT60
P3: CONN_01X02; Pin_Header_Straight_1x02
Q1: IRFB7537PbF; my_TO-220_Neutral123_Horizontal_LargePads
R1: 4.7k; R_0805
R2: 10k; R_0805
U1: NSI45020AT1G; SOD-123
U2: LM3490IM5-12/NOPB; SOT-23-5

Connections:
+BATT: P1.2 (+), P2.2 (+), P3.2, U2.4 (VIN)
After_Load-: P2.1 (-), Q1.2 (D)
GND: D1.1 (K), P1.1 (-), Q1.3 (S), R1.2, R2.2, U2.2 (GND)
unnamed: D1.2 (A), R2.1, U1.1 (Cathode), U2.3 (Enable)
unnamed: P3.1, U1.2 (Anode)
unnamed: Q1.1 (G), R1.1, U2.5 (VOUT)

Board: 2 copper layers, 76.2 x 17.8 mm, 9 parts (4 on the bottom side), 6 nets.

## KiCad design projects/johaa1993_pdb_pca9698/current_version/working/working.kicad_pcb

File projects/johaa1993_pdb_pca9698/current_version/working/readme.md:

# pdb
 
## summary 
* id: johaa1993_pdb_pca9698
* user: johaa1993
* name: pdb
* board: pca9698
* repo: https://github.com/johaa1993/PDB
* src_file_repo_kicad_pcb: PCA9698/PCA9698.kicad_pcb
* src_file_repo_kicad_pcb_link: https://github.com/johaa1993/PDB/tree/master/PCA9698/PCA9698.kicad_pcb

* src_file_repo_sch: PCA9698/PCA9698.sch
* src_file_repo_sch_link: https://github.com/johaa1993/PDB/tree/master/PCA9698/PCA9698.sch
* full details link: https://github.com/oomlout/oomlout_oomp_project_bot_v_2/tree/main/projects/johaa1993_pdb_pca9698/current_version/working

Parts:
D1: LED; LED_0805
P1: Power connector; Pin_Header_Straight_1x10
P2, P4, P10: CONN_01X03; Pin_Header_Straight_1x03
P3: I2C connector; Pin_Header_Straight_1x05
P5: GPIO 0; Pin_Header_Straight_1x08
P6: GPIO 1; Pin_Header_Straight_1x08
P7: GPIO 2; Pin_Header_Straight_1x08
P8: GPIO 3; Pin_Header_Straight_1x08
P9: GPIO 4; Pin_Header_Straight_1x08
R1: R; R_0805
U2: PCA9698; TSSOP-56_6.1x14mm_Pitch0.5mm

Connections:
+3V3: P1.6, P1.7, P1.8, P1.9, P1.10, P2.3, P10.3, R1.2, U2.18 (VDD), U2.46 (VDD)
/INT: D1.1 (K), U2.55 (INT/SMBALERT)
/OE: P2.2, U2.30 (OE)
/Reset: P10.2, U2.56 (RESET)
/SCL: P3.4, P3.5, U2.2 (SCL)
/SDA: P3.2, P3.3, U2.1 (SDA)
GND: P1.1, P1.2, P1.3, P1.4, P1.5, P2.1, P3.1, P10.1, U2.6 (VSS), U2.11 (VSS), U2.23 (VSS), U2.34 (VSS), U2.39 (VSS), U2.51 (VSS)
unnamed: D1.2 (A), R1.1
unnamed: P4.1, U2.29 (AD2)
unnamed: P4.2, U2.28 (AD1)
unnamed: P4.3, U2.27 (AD0)
unnamed: P5.1, U2.3 (IO_0_0)
unnamed: P5.2, U2.4 (IO_0_1)
unnamed: P5.3, U2.5 (IO_0_2)
unnamed: P5.4, U2.7 (IO_0_3)
unnamed: P5.5, U2.8 (IO_0_4)
unnamed: P5.6, U2.9 (IO_0_5)
unnamed: P5.7, U2.10 (IO_0_6)
unnamed: P5.8, U2.12 (IO_0_7)
unnamed: P6.1, U2.13 (IO_1_0)
unnamed: P6.2, U2.14 (IO_1_1)
unnamed: P6.3, U2.15 (IO_1_2)
unnamed: P6.4, U2.16 (IO_1_3)
unnamed: P6.5, U2.17 (IO_1_4)
unnamed: P6.6, U2.19 (IO_1_5)
unnamed: P6.7, U2.20 (IO_1_6)
unnamed: P6.8, U2.21 (IO_1_7)
unnamed: P7.1, U2.22 (IO_2_0)
unnamed: P7.2, U2.24 (IO_2_1)
unnamed: P7.3, U2.25 (IO_2_2)
unnamed: P7.4, U2.26 (IO_2_3)
unnamed: P7.5, U2.31 (IO_2_4)
unnamed: P7.6, U2.32 (IO_2_5)
unnamed: P7.7, U2.33 (IO_2_6)
unnamed: P7.8, U2.35 (IO_2_7)
unnamed: P8.1, U2.36 (IO_3_0)
unnamed: P8.2, U2.37 (IO_3_1)
unnamed: P8.3, U2.38 (IO_3_2)
unnamed: P8.4, U2.40 (IO_3_3)
unnamed: P8.5, U2.41 (IO_3_4)
unnamed: P8.6, U2.42 (IO_3_5)
unnamed: P8.7, U2.43 (IO_3_6)
unnamed: P8.8, U2.44 (IO_3_7)
unnamed: P9.1, U2.45 (IO_4_0)
unnamed: P9.2, U2.47 (IO_4_1)
unnamed: P9.3, U2.48 (IO_4_2)
unnamed: P9.4, U2.49 (IO_4_3)
unnamed: P9.5, U2.50 (IO_4_4)
unnamed: P9.6, U2.52 (IO_4_5)
unnamed: P9.7, U2.53 (IO_4_6)
unnamed: P9.8, U2.54 (IO_4_7)

Notices in the files:
projects/johaa1993_evbms_6802_2slv/current_version/working/working.kicad_pcb:
Licensed under the TAPR Open Hardware License (www.tapr.org/OHL)
