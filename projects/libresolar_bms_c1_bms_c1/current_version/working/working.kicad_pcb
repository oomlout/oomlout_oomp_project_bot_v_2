# Repository oomlout/oomlout_oomp_project_bot_v_2

## KiCad design projects/libresolar_bms_c1_bms_c1/current_version/working/working.kicad_pcb

File projects/libresolar_bms_c1_bms_c1/current_version/working/readme.md:

# bms_c1
 
## summary 
* id: libresolar_bms_c1_bms_c1
* user: libresolar
* name: bms_c1
* board: bms_c1
* repo: https://github.com/LibreSolar/bms-c1
* src_file_repo_kicad_pcb: kicad/bms-c1.kicad_pcb
* src_file_repo_kicad_pcb_link: https://github.com/LibreSolar/bms-c1/tree/main/kicad/bms-c1.kicad_pcb
* src_file_repo_kicad_sch: kicad/bms-c1.kicad_sch
* src_file_repo_kicad_sch_link: https://github.com/LibreSolar/bms-c1/tree/main/kicad/bms-c1.kicad_sch

* src_file_repo_sch: 
* src_file_repo_sch_link: https://github.com/LibreSolar/bms-c1/tree/main/
* full details link: https://github.com/oomlout/oomlout_oomp_project_bot_v_2/tree/main/projects/libresolar_bms_c1_bms_c1/current_version/working

Board: 4 copper layers, 135.0 x 70.0 mm, 206 parts (0 on the bottom side), 115 nets.

Parts:
C1, C2, C3, C4, C5, C6, C7, C8, C9, C10, C11, C12, C13, C14, C15, C16, C26: 220nF; C_0603_1608
C17, C18: 47µF; C_1210_3225
C19, C24, C28, C31, C34, C36, C37, C40, C48, C49, C50, C51, C52: 100nF; C_0603_1608
C20: 2.2µF; C_0603_1608
C22, C23: 2.2µF; C_1210_3225
C25: 1µF; C_1206_3216
C27, C29, C32, C33, C35: 100pF; C_0603_1608
C30, C47: 1µF; C_0603_1608
C46: 10µF; C_0805_2012
D1, D6, D13: PMEG10010ELRX; D_SOD-123F
D2, D5, D10, D15, D16, D20: BAT46W; D_SOD-123
D3, D4, D7: ESD5B5.0ST1G; D_SOD-523
D8: PESD2CANFD; SOT-23
D9: VSS8D3M10-M3/I; D_SOD-128
D11: 3.6V; D_SOD-123
D12, D22: SMCJ60A; D_SMC
D14, D17, D21, D24: 16V; D_SOD-123
D19: 5.1V; D_SOD-323
D23: 75V; D_SOD-123
FID1, FID2: Fiducial; Fiducial_1mm_Mask2mm
H1, H2, H3, H4, H5, H6: MountingHole; MountingHole_3.2mm_M3_Pad_TopBottom
J1: MicroFit 2x12; Molex_Micro-Fit_3.0_43045-2410_2x12-1MP_P3.00mm_Horizontal
J2, J6: B4B-PH-SM4; JST_PH_B4B-PH-SM4-TB_1x04-1MP_P2.00mm_Vertical
J3: USB_B_Micro; USB_Micro-B_10103594-0001LF
J4: B3B-PH-SM4; JST_PH_B3B-PH-SM4-TB_1x03-1MP_P2.00mm_Vertical
J5: B2B-PH-SM4; JST_PH_B2B-PH-SM4-TB_1x02-1MP_P2.00mm_Vertical
L2: 10µH; Bourns_SRN8040TA
LED1: LED red; LED_0603_1608Metric
LED2: LED green; LED_0603_1608Metric
LOGO1: OPEN_HARDWARE; OSHW-Logo_5.7x6mm_SilkScreen
LOGO2: LIBRE_SOLAR; LIBRESOLAR_LOGO
NT1: NetTie; NetTie-2_SMD_Pad0.5mm
P1, P2, P3, P4: CONN_01X01; Wuerth_PowerOne_SMD_LF990005
P5: CONN_01X01; SolderWirePad_1x01_SMD_5x10mm
Q1: DMN10H220LE; SOT-223
Q2, Q3, Q4, Q5, Q6, Q7, Q8, Q9: IPT015N10N5; Infineon_PG-HSOF-8-1_ThermalVias
Q10: BSS84; SOT-23
Q11: BSS123N; SOT-23
Q12: ZXMP10A17GTA; SOT-223-3_TabPin2
R1, R2, R3, R4, R5, R6, R7, R8, R9, R10, R11, R12, R13, R14, R15, R16, R17: 20; R_2010_5025
R18: 100; R_1206_3216
R19, R20, R38, R44: 100; R_0603_1608
R21, R37: 0R; R_0603_1608
R22, R23, R46: 1k; R_0603_1608
R24, R29, R30, R60, R68: 10k; R_0603_1608
R25: 10; R_1206_3216
R26, R62: 1M; R_0603_1608
R27: 330k; R_0603_1608
R28, R65: 100k; R_0603_1608
R31: 29.4k; R_0603_1608
R32, R33: 2.2k; R_0603_1608
R34: 49.9k; R_0603_1608
R39, R52, R59: 10M; R_0603_1608
R40, R41, R42, R43, R47, R48, R49, R50: 47; R_0603_1608
R45: 300µ; R_Shunt_5931_Kelvin
R51, R61: 68k; R_0603_1608
R53: 6.8k; R_0603_1608
R54: 4.7k; R_0603_1608
R56, R64: 62R; R_0603_1608
R57, R58: 470; R_0603_1608
R63: 40; Bourns_PWR163
RT1: 10k; R_0603_1608
S1, S2: SW_PUSH; SW_SPST_TL3305A
TP1, TP2, TP3, TP4, TP5, TP6, TP7, TP8, TP9, TP10, TP11, TP12, TP13, TP14, TP15: TestPoint; TestPoint_Pad_D1.5mm
TP16, TP17, TP18, TP19, TP20, TP21, TP22, TP23, TP24, TP25, TP26, TP27, TP28, TP29, TP30, TP31, TP32: TestPoint; TestPoint_Pad_1.0x1.0mm
U1: SN65HVD230; SOIC-8_3.9x4.9mm_P1.27mm
U2: LMR16030; SOIC-8-1EP_3.9x4.9mm_P1.27mm_EP2.29x3mm
U4: BQ76952; TQFP-48_7x7mm_P0.5mm
U5: ESP32-C3-MINI-1

Connections:
+3V3: C17.1, C18.1, C19.1, C36.1, C46.1, D13.2 (A), J2.3, J6.3, L2.2, R24.2, R26.2, R28.1, R32.2, R33.2, R68.2, U1.3 (VCC), U5.3 (3V3)
+5V: D6.2 (A), D7.2 (A2), J3.1 (VBUS)
/BAT+: C34.1, C49.1, D1.2 (A), D2.1 (K), D12.1 (K), D14.2 (A), J1.12, P1.1, Q2.2 (S), Q3.2 (S), Q4.2 (S), Q5.2 (S), R39.2
/BAT-: C48.2, D12.2 (A), J1.3, NT1.1, P2.1, R45.1
/BQ76952/ALERT: R26.1, TP8.1, U4.25 (ALERT), U5.5 (GPIO2/ADC1_CH2)
/BQ76952/BAT: C25.1, C29.1, C30.2, R18.1, U4.47 (BAT)
/BQ76952/BTN_HIGH: D13.1 (K), J5.1, R54.1, S1.2
/BQ76952/CHG: R38.1, TP4.1, U4.45 (CHG)
/BQ76952/CP1: C30.1, TP1.1, U4.46 (CP1)
/BQ76952/DSG: R44.1, TP6.1, U4.43 (DSG)
/BQ76952/LD: R30.1, U4.41 (LD)
/BQ76952/PACK: R29.1, U4.42 (PACK)
/BQ76952/PDSG: D23.1 (K), R61.1, TP7.1, U4.39 (PDSG)
/BQ76952/SHUNT_N: R20.1, R45.3
/BQ76952/SHUNT_P: R19.1, R45.2
/BQ76952/SRN: C27.2, C28.2, R20.2, U4.20 (SRN)
/BQ76952/SRP: C27.1, C28.1, R19.2, U4.18 (SRP)
/BQ76952/VC0: C1.2, C26.1, D10.1 (K), D11.1 (K), R1.2, TP16.1, U4.16 (VC0)
/BQ76952/VC1: C1.1, C2.2, R2.2, TP17.1, U4.15 (VC1)
/BQ76952/VC2: C2.1, C3.2, R3.2, TP18.1, U4.14 (VC2)
/BQ76952/VC3: C3.1, C4.2, R4.2, TP19.1, U4.13 (VC3)
/BQ76952/VC4: C4.1, C5.2, R5.2, TP20.1, U4.12 (VC4)
/BQ76952/VC5: C5.1, C6.2, R6.2, TP21.1, U4.11 (VC5)
/BQ76952/VC6: C6.1, C7.2, R7.2, TP22.1, U4.10 (VC6)
/BQ76952/VC7: C7.1, C8.2, R8.2, TP23.1, U4.9 (VC7)
/BQ76952/VC8: C8.1, C9.2, R9.2, TP24.1, U4.8 (VC8)
/BQ76952/VC9: C9.1, C10.2, R10.2, TP25.1, U4.7 (VC9)
/BQ76952/VC10: C10.1, C11.2, R11.2, TP26.1, U4.6 (VC10)
/BQ76952/VC11: C11.1, C12.2, R12.2, TP27.1, U4.5 (VC11)
/BQ76952/VC12: C12.1, C13.2, R13.2, TP28.1, U4.4 (VC12)
/BQ76952/VC13: C13.1, C14.2, R14.2, TP29.1, U4.3 (VC13)
/BQ76952/VC14: C14.1, C15.2, R15.2, TP30.1, U4.2 (VC14)
/BQ76952/VC15: C15.1, C16.2, R16.2, TP31.1, U4.1 (VC15)
/BQ76952/VC16: C16.1, R17.2, TP32.1, U4.48 (VC16)
/BQ76952/WAKE: R54.2, TP15.1, U4.22 (TS2)
/BTN_LOW: C31.2, J5.2, R53.2, S1.1, TP10.1, U5.6 (GPIO3/ADC1_CH3)
/C1+: J1.4, R2.1
/C1-: J1.15, R1.1
/C2+: J1.16, R3.1
/C3+: J1.5, R4.1
/C4+: J1.17, R5.1
/C5+: J1.6, R6.1
/C6+: J1.18, R7.1
/C7+: J1.7, R8.1
/C8+: J1.19, R9.1
/C9+: J1.8, R10.1
/C10+: J1.20, R11.1
/C11+: J1.9, R12.1
/C12+: J1.21, R13.1
/C13+: J1.10, R14.1
/C14+: J1.22, R15.1
/C15+: J1.11, R16.1
/C16+: D2.2 (A), D5.2 (A), J1.23, R17.1
/CAN_H: D8.2 (K), J4.1, R56.1, TP2.1, U1.7 (CANH)
/CAN_L: D8.1 (K), J4.2, R64.2, TP3.1, U1.6 (CANL)
/CHG+: D24.1 (K), P5.1, Q2.3 (D), Q3.3 (D), Q4.3 (D), Q5.3 (D), Q6.3 (D), Q7.3 (D), Q8.3 (D), Q9.3 (D), Q12.3 (S), R62.1, TP9.1
/ESP32-C3 MCU/BOOT: TP11.1, U5.23 (GPIO9)
/ESP32-C3 MCU/CAN_RX: U1.4 (R), U5.18 (GPIO4/ADC1_CH4)
/ESP32-C3 MCU/CAN_STB: R21.2, U5.16 (GPIO10)
/ESP32-C3 MCU/CAN_TX: U1.1 (D), U5.19 (GPIO5/ADC2_CH0)
/ESP32-C3 MCU/NRST: C47.1, R68.1, S2.2, U5.8 (EN/CHIP_PU)
/ESP32-C3 MCU/USB_D+: D4.2 (A2), J3.3 (D+), U5.27 (GPIO19/USB_D+)
/ESP32-C3 MCU/USB_D-: D3.2 (A2), J3.2 (D-), U5.26 (GPIO18/USB_D-)
/FUSE: J1.24, R25.2, TP14.1
/I2C_SCL: J2.1, R33.1, TP13.1, U4.26 (SCL), U5.21 (GPIO7)
/I2C_SDA: J2.2, R32.1, TP12.1, U4.27 (SDA), U5.20 (GPIO6)
/LED_GREEN: R23.2, U5.12 (GPIO0/ADC1_CH0/XTAL_32K_P)
/LED_RED: R22.2, U5.13 (GPIO1/ADC1_CH1/XTAL_32K_N)
/PACK+: C50.2, C51.1, D17.2 (A), D21.2 (A), D22.1 (K), P3.1, Q6.2 (S), Q7.2 (S), Q8.2 (S), Q9.2 (S), Q11.2 (S), R29.2, R30.2, R52.2, R57.1, R59.2, R63.2, R63.3
/PACK-: C52.2, D22.2 (A), P4.1, R45.4, R60.1
/Power Part/CHG_G: D14.1 (K), R38.2, R39.1, R40.1, R41.1, R42.1, R43.1
/Power Part/DSG_G: D17.1 (K), D19.1 (K), Q10.2 (S), R47.2, R48.2, R49.2, R50.2, R52.1, R58.1
/Power Supply/EN: R37.1, U2.3 (EN)
/Power Supply/FB: R28.2, R31.1, U2.5 (FB)
/Power Supply/SW: C24.2, D9.1 (K), L2.1, U2.8 (SW)
/Power Supply/VIN: C22.1, C23.1, C40.1, D1.1 (K), D6.1 (K), U2.2 (VIN)
/REG18: C20.1, R37.2, TP5.1, U4.24 (REG18)
/TEMP1: C32.1, J1.13, U4.21 (TS1)
/TEMP2: C33.1, J1.14, U4.23 (TS3)
/TEMP_FETS: C35.1, RT1.2, U4.31 (DCHG)
/UART_RX: J6.2, U5.30 (GPIO20/U0RXD)
/UART_TX: J6.1, U5.31 (GPIO21/U0TXD)
GND: C17.2, C18.2, C19.2, C20.2, C22.2, C23.2, C25.2, C26.2, C29.2, C31.1, C32.2, C33.2, C35.2, C36.2, C37.2, C40.2, C46.2, C47.2, D3.1 (A1), D4.1 (A1), D7.1 (A1), D8.3 (A), D9.2 (A), D10.2 (A), D11.2 (A), D15.2 (A), D23.2 (A), J1.1, J1.2, J1.MP (MountPin), J2.4, J2.MP (MountPin), J3.5 (GND), J3.6 (Shield), J4.3, J4.MP (MountPin), J5.MP (MountPin), J6.4, J6.MP (MountPin), LED1.1 (K), LED2.1 (K), NT1.2, Q1.3 (S), R27.2, R31.2, R34.2, R53.1, R65.2, RT1.1, S2.1, U1.2 (GND), U2.7 (GND), U2.9 (PADGND), U4.17 (VSS), U4.33 (RST_SHUT), U4.36 (REGIN), U4.37 (BREG), U5.1 (GND), U5.2 (GND), U5.11 (GND), U5.14 (GND), U5.36 (GND)
unnamed: C24.1, U2.1 (BOOT)
unnamed: C34.2, C48.1
unnamed: C37.1, R56.2, R64.1
unnamed: C49.2, C50.1
unnamed: C51.2, C52.1
unnamed: D5.1 (K), R18.2
unnamed: D15.1 (K), R44.2, R46.1
unnamed: D16.1 (K), D19.2 (A), Q10.1 (G), R51.2
unnamed: D16.2 (A), R46.2, R51.1
unnamed: D20.1 (K), D21.1 (K), Q11.1 (G), R59.1
unnamed: D20.2 (A), R60.2
unnamed: D24.2 (A), Q12.1 (G), R61.2, R62.2
unnamed: J3.4 (ID), R27.1
unnamed: LED1.2 (A), R22.1
unnamed: LED2.2 (A), R23.1
unnamed: Q1.1 (G), U4.38 (FUSE)
unnamed: Q1.2 (D), Q1.4 (D), R25.1
unnamed: Q2.1 (G), R40.2
unnamed: Q3.1 (G), R41.2
unnamed: Q4.1 (G), R42.2
unnamed: Q5.1 (G), R43.2
unnamed: Q6.1 (G), R47.1
unnamed: Q7.1 (G), R48.1
unnamed: Q8.1 (G), R49.1
unnamed: Q9.1 (G), R50.1
unnamed: Q10.3 (D), R57.2
unnamed: Q11.3 (D), R58.2
unnamed: Q12.2 (D), R63.1
unnamed: R21.1, U1.8 (Rs)
unnamed: R24.1, U5.22 (GPIO8)
unnamed: R34.1, U2.4 (RT/SYNC)
unnamed: R65.1, U4.34 (REG2), U4.35 (REG1)

## KiCad design projects/libresolar_data_manager_data_manager/current_version/working/working.kicad_pcb

File projects/libresolar_data_manager_data_manager/current_version/working/readme.md:

# data_manager
 
## summary 
* id: libresolar_data_manager_data_manager
* user: libresolar
* name: data_manager
* board: data_manager
* repo: https://github.com/LibreSolar/data-manager
* src_file_repo_kicad_pcb: kicad/data-manager.kicad_pcb
* src_file_repo_kicad_pcb_link: https://github.com/LibreSolar/data-manager/tree/master/kicad/data-manager.kicad_pcb

* src_file_repo_sch: kicad/data-manager.sch
* src_file_repo_sch_link: https://github.com/LibreSolar/data-manager/tree/master/kicad/data-manager.sch
* full details link: https://github.com/oomlout/oomlout_oomp_project_bot_v_2/tree/main/projects/libresolar_data_manager_data_manager/current_version/working

Parts:
C1, C10: 10uF; C_0805_2012; PartNumber GRM21BR61C106KE15L
C2, C3, C11: 2.2u; C_0603_1608
C4, C5: 47p; C_0603_1608
C6, C7, C8, C9: 100n; C_0603_1608
H1, H2, H3, H4: MountingHole; MountingHole_3mm
J1: Micro_SD_Card; microSD_HC_Hirose_DM3D-SF; PartNumber DM3D-SF
J2: 6P6C; RJ12_RJ25_6P6C_Amphenol_54601; PartNumber 54601-906WPLF
J3: USB_B_Micro; USB_Micro-B_10103594-0001LF
J4, J5: 8P8C; RJ45_8P8C
LED1: LED; LED_0603_1608Metric
LOGO1: LibreSolar_Logo; LIBRESOLAR_LOGO
LOGO2: Logo_Open_Hardware_Small; OSHW-Logo_5.7x6mm_SilkScreen
Q1, Q2: MMBT3904; SOT-23
R1, R2, R7, R8: 10k; R_0603_1608; PartNumber RC0603FR-0710KL
R3: 1k; R_0603_1608; PartNumber RC0603FR-071KL
R4, R5: 27; R_0603_1608; PartNumber RC0603FR-0727RL
R6: 120R; R_1206_3216; PartNumber RC1206FR-07120RL
U1: ESP32-WROOM-32D; ESP32-WROOM-32
U2: SI8621AB-B-ISR; SOIC-8_3.9x4.9mm_P1.27mm
U3: AP2210-3.3; SOT-23-5
U4: FT231XS; SSOP-20_3.9x8.7mm_P0.635mm
U5: TCAN334; SOIC-8_3.9x4.9mm_Pitch1.27mm

Connections:
+3V3: C1.1, C3.1, C8.1, C9.1, C10.1, J1.4 (VDD), R7.1, R8.2, U1.2 (VDD), U2.8 (VCC2), U3.5 (OUT), U5.3 (VCC)
+5V: C2.1, C7.1, J3.1 (VBUS), U3.1 (IN), U3.3 (EN), U4.15 (VCC)
/CANH: J4.1, J5.1, R6.1, U5.7 (CANH)
/CANL: J4.2, J5.2, R6.2, U5.6 (CANL)
/CAN_RX: U1.26 (IO4), U5.4 (RXD)
/CAN_STB: U1.14 (IO12), U5.8 (STB)
/CAN_TX: U1.29 (IO5), U5.1 (TXD)
/DTR: Q1.2 (E), R2.2, U4.1 (~DTR)
/GND_EXT: J2.4, U2.4 (GND1)
/GPIO0: Q1.3 (C), U1.25 (IO0)
/LED1: R3.2, U1.30 (IO18)
/RESET: C11.1, Q2.3 (C), R8.1, U1.3 (EN)
/RTS: Q2.2 (E), R1.2, U4.2 (~RTS)
/RX_EXT: J2.2, U2.3 (OUTB)
/SD_CLK: J1.5 (CLK), U1.13 (IO14)
/SD_CMD: J1.3 (CMD), U1.23 (IO15)
/SD_DAT0: J1.7 (DAT0), U1.24 (IO2)
/TX_EXT: J2.3, U2.2 (INA)
/U0_RX: U1.34 (RXD0/IO3), U4.20 (TXD)
/U0_TX: U1.35 (TXD0/IO1), U4.4 (RXD)
/U2_RX: U1.27 (IO16), U2.7 (OUTA)
/U2_TX: U1.28 (IO17), U2.6 (INB)
/USB_D+: C4.1, J3.3 (D+), R4.1
/USB_D-: C5.1, J3.2 (D-), R5.1
/VCC_EXT: J2.1, U2.1 (VCC1)
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, J1.6 (VSS), J1.9 (SHIELD), J3.5 (GND), J4.7, J5.7, LED1.1 (K), U1.1 (GND), U1.15 (GND), U1.38 (GND), U2.5 (GND2), U3.2 (GND), U4.6 (GND), U4.16 (GND), U5.2 (GND)
unnamed: C6.1, U4.3 (VCCIO), U4.13 (3V3OUT), U4.14 (~RESET)
unnamed: J1.2 (DAT3/CD), R7.2
unnamed: J4.3, J5.3
unnamed: J4.4, J5.4
unnamed: J4.5, J5.5
unnamed: J4.6, J5.6
unnamed: J4.8, J5.8
unnamed: LED1.2 (A), R3.1
unnamed: Q1.1 (B), R1.1
unnamed: Q2.1 (B), R2.1
unnamed: R4.2, U4.11 (USBDP)
unnamed: R5.2, U4.12 (USBDM)

Notes on the sheet:
LS.bus CAN interface
ESP32 WROOM module
UART at IO1/3 for programming
See Sparkfun / Adafruit boards
Data Manager - LS.one and LS.bus to WiFi gateway
Pinout for SD card from: https://github.com/espressif/esp-idf/tree/master/examples/storage/sd_card
USB to UART converter for ESP programming
Reset and boot circuit
Micro-SD card
LS.one isolated UART interface
USB power supply
UART at IO16/17 for AT commands

Board: 2 copper layers, 74.0 x 38.0 mm, 38 parts (0 on the bottom side), 38 nets.

## KiCad design projects/libresolar_mppt_1210_hus_mppt_1210_hus/current_version/working/working.kicad_pcb

File projects/libresolar_mppt_1210_hus_mppt_1210_hus/current_version/working/readme.md:

# mppt_1210_hus
 
## summary 
* id: libresolar_mppt_1210_hus_mppt_1210_hus
* user: libresolar
* name: mppt_1210_hus
* board: mppt_1210_hus
* repo: https://github.com/LibreSolar/mppt-1210-hus
* src_file_repo_kicad_pcb: kicad/mppt-1210-hus.kicad_pcb
* src_file_repo_kicad_pcb_link: https://github.com/LibreSolar/mppt-1210-hus/tree/main/kicad/mppt-1210-hus.kicad_pcb

* src_file_repo_sch: 
* src_file_repo_sch_link: https://github.com/LibreSolar/mppt-1210-hus/tree/main/
* full details link: https://github.com/oomlout/oomlout_oomp_project_bot_v_2/tree/main/projects/libresolar_mppt_1210_hus_mppt_1210_hus/current_version/working

Board: 2 copper layers, 90.0 x 85.0 mm, 132 parts (8 on the bottom side), 79 nets.

Parts:
C1: 1200u; CP_Radial_L31.5mm_D16.0mm_P7.50mm_horizontal
C2: 150u; CP_Elec_8x6.2
C3: 4.7u; C_1210_3225
C4, C7, C8, C17, C18, C27, C28, C37, C41, C44: 10n; C_0603_1608
C5: 820u; CP_Radial_D10.0mm_P5.00mm
C6, C11, C13: 1n; C_0603_1608
C9, C10, C19, C24, C25, C26, C30, C31, C32, C39, C42, C43: 100n; C_0603_1608
C12, C23, C33, C34, C38: 2.2u; C_0603_1608
C14: 1u; C_0805_2012
C15: 10u; C_1210_3225
C20, C21, C36, C40: 22u; C_1206_3216
C29: 220n; C_0603_1608
C35: 100p; C_0603_1608
D1, D4, D7: 1N4148; D_SOD-123
D5: SMBJ24A; D_SMB
D6: SS14FL; D_SOD-123
F1: 25A; KEYSTONE-FUSE-3557-2
F2: 50mA; R_1206_3216
J1, J2, J3: MKDS_5-2_952; Phoenix_Contact_MKDS_5-2-952
J4: UEXT; Box_Header_2x05x2.54mm_Straight
J5: USB_A_stacked; USB_A_Wuerth_61400826021_Horizontal_Stacked
J6: PWR_12V; JST_XH_B02B-XH-A_1x02_P2.50mm_Vertical
J7: 6P6C; RJ25_6P6C_TabUp
J8: ST_Nucleo_SWD; PinHeader_1x05_P2.54mm_Vertical
L1: 47uH; L-FERYSTER-DTMSS-27_47uH
L2: 2.2uH; L_1210_3225Metric
L3: 10uH; Bourns_SRN8040TA
LED1, LED2, LED3: yellow; LED_0603_D3.0mm
LED4, LED5: green; LED_0603_D3.0mm
LOGO1: LIBRE_SOLAR; LIBRESOLAR_LOGO
LOGO2: OPEN_HARDWARE; OSHW-Logo_5.7x6mm_SilkScreen
MK1, MK2, MK3, MK4: Mounting_Hole; MountingHole_3.2mm_M3_Pad
Q1, Q2, Q4: PSMN5R2-60YLX; 5X6_MOSFET
Q3: BSC084P03NS3; 5X6_MOSFET
Q5, Q6, Q7: BSS83P; SOT-23
R1, R3, R10: 4.7; R_0805_2012
R2: 1M; R_0603_1608
R4: 2.2; R_1206_3216
R5, R7, R13, R30, R33, R34: 2.2k; R_0603_1608
R6, R17: 3m; R_Bourns_CRE2512
R8: 100; R_0603_1608
R9, R16, R19, R31: 10k; R_0603_1608
R11, R14, R15, R18, R20, R21: 470; R_0603_1608
R12, R22, R23, R24, R25, R28, R35, R36: 100k; R_0603_1608
R26, R27: 5.6k; R_0603_1608
R29, R32: 24.9k; R_0603_1608
RT1: 10k NTC; R_0603_1608
T1, T2: MMBT3904; SOT-23
TP1, TP2, TP3, TP4, TP5, TP6, TP7, TP9: Test_Point_Probe; TestPoint_Pad_D1.0mm
U1: LM5109BMA; SOIC-8_3.9x4.9mm_Pitch1.27mm
U2: STM32L072CZT6; LQFP-48_7x7mm_P0.5mm
U3, U4: D1213A-04SO; SOT-23-6
U5: AP2210-3.3; SOT-23-5
U6: INA2181; VSSOP-10_3.0x3.0mm_P0.5mm
U9: LMR33630; TI_SO-PowerPAD-8_ThermalVias

Connections:
5V_PG: Q5.3, R23.2, U2.4
+3V3: C9.1, C30.1, C31.1, C32.1, C33.1, C38.1, F2.2, J4.1, J8.1, Q5.2, R5.2, R8.1, R22.1, R30.2, TP9.1, U2.1, U2.24, U2.36, U2.48, U5.5, U6.10
+5V: C20.1, C21.1, C36.1, C40.1, D7.2, J5.1, J5.5, L3.2, R28.1, TP7.1, U4.5
+12V: F1.1, R6.2, R17.1, R25.1, TP1.1, U6.2, U6.7
/DCDC power stage/BAT+: C7.1, F1.2, J3.1
/DCDC power stage/HS_DRV: R1.2, U1.7
/DCDC power stage/LS_DRV: D6.1, R3.2, U1.5
/DCDC power stage/SOLAR+: C1.1, C3.1, C4.1, C8.1, J1.1, Q1.D, Q7.2, R32.1
/DCDC power stage/SOLAR-: C8.2, J1.2, Q2.D
/DCDC power stage/SW_NODE: C6.1, C10.2, L1.1, Q1.S, Q4.D, U1.6
/MCU/BOOT0: C43.1, R7.2, R33.2, R35.2, U2.44
/MCU/BUTTON: R7.1, U2.25
/MCU/I2C1_SCL: J4.5, R30.1, U2.42
/MCU/I2C1_SDA: J4.6, R5.1, U2.43
/MCU/LED_A: R14.1, U2.26
/MCU/LED_B: LED3.1, R15.1, U2.27
/MCU/LED_C: LED1.1, LED2.2, LED4.2, LED5.1, U2.20
/MCU/SPI1_MISO: J4.7, U2.40
/MCU/SPI1_MOSI: J4.8, U2.41
/MCU/SPI1_SCK: J4.9, U2.39
/MCU/SSEL: J4.10, U2.38
/MCU/SWCLK: J8.2, U2.37
/MCU/SWDIO: J8.4, U2.34
/MCU/TEMP_EXT: J7.5, R19.2, R34.1, RT1.1, U3.1
/MCU/TEMP_INT_PD: RT1.2, U2.29
/MCU/USART1_RX: R18.2, R22.2, U2.31
/MCU/USART1_TX: R21.2, U2.30
/MCU/USART2_RX: J4.4, U2.13
/MCU/USART2_TX: J4.3, U2.12
/MCU/~RESET: C39.1, J8.5, U2.7
DAC: C42.1, TP6.1, U2.14, U6.5, U6.6
DCDC_OUT: C5.1, C12.1, C37.1, D4.2, L1.2, Q6.2, R6.1, R12.2, U1.1, U6.3
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C7.2, C9.2, C11.2, C12.2, C13.2, C14.2, C15.2, C17.2, C18.2, C20.2, C21.2, C23.2, C24.2, C25.2, C26.2, C27.2, C29.2, C30.2, C31.2, C32.2, C33.2, C34.2, C35.2, C36.2, C37.2, C38.2, C39.2, C40.2, C41.2, C42.2, C43.2, C44.2, D5.2, J2.2, J3.2, J4.2, J5.4, J5.8, J6.2, J7.4, J8.3, MK1.1, MK2.1, MK3.1, MK4.1, Q2.S, Q4.S, R2.1, R4.1, R23.1, R26.2, R27.2, R29.2, R35.1, T1.2, T2.2, U1.4, U2.8, U2.23, U2.35, U2.47, U3.2, U4.2, U5.2, U6.4, U9.1, U9.9
I_DCDC: C13.1, R20.2, TP4.1, U2.16
I_LOAD: C11.1, R11.2, TP5.1, U2.15
LOAD+: C27.1, C28.1, D5.1, J2.1, Q3.D
LOAD_EN: R13.2, U2.2
LOAD_S: C14.1, J6.1, L2.1, Q3.S, R9.2, R17.2, U6.8
unnamed: C6.2, R4.2
unnamed: C10.1, R10.1
unnamed: C2.1, C15.1, C29.1, L2.2, U9.2
unnamed: C19.1, U9.7
unnamed: C19.2, L3.1, U9.8
unnamed: C23.1, D7.1, Q6.3, U5.1, U5.3
unnamed: C24.1, F2.1, J7.1, U3.5
unnamed: C25.1, J5.9
unnamed: C26.1, U9.6
unnamed: C28.2, Q3.G, R9.1, R16.2
unnamed: C35.1, U5.4
unnamed: D1.1, Q2.G, R2.2
unnamed: D1.2, D6.2, Q4.G, R3.1
unnamed: D4.1, R10.2, U1.8
unnamed: J5.2, J5.3
unnamed: J7.2, R18.1, U3.6
unnamed: J7.3, R21.1, U3.4
unnamed: J7.6, R33.1, U3.3
unnamed: LED1.2, LED2.1, LED3.2, R14.2
unnamed: LED4.1, LED5.2, R15.2
unnamed: Q1.G, R1.1
unnamed: Q5.1, Q6.1, R12.1, U9.4
unnamed: Q7.1, R32.2, R36.2
unnamed: Q7.3, R24.1
unnamed: R11.1, U6.9
unnamed: R13.1, T1.1
unnamed: R16.1, T1.3
unnamed: R20.1, U6.1
unnamed: R28.2, R29.1, U9.5
unnamed: R31.1, T2.1
unnamed: R36.1, T2.3
PWM_HS: TP2.1, U1.2, U2.18
PWM_LS: TP3.1, U1.3, U2.19
T_BAT: C44.1, R34.2, U2.17
USB_DM: J5.6, U2.32, U4.3
USB_DP: J5.7, U2.33, U4.1
USB_PWR_EN: U2.21, U9.3
VDDA: C34.1, C41.1, R8.2, R19.1, U2.9
V_BAT: C18.1, R25.2, R27.1, U2.10
V_SOLAR: C17.1, R24.2, R26.1, U2.11
V_SOLAR_EN: R31.2, U2.3

Notices in the files:
projects/libresolar_bms_c1_bms_c1/current_version/working/working.kicad_pcb:
License: CERN-OHL-W
projects/libresolar_mppt_1210_hus_mppt_1210_hus/current_version/working/working.kicad_pcb:
Licensed under CERN-OHL-W version 2
