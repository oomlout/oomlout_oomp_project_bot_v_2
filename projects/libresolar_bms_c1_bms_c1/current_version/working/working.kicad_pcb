# Repository oomlout/oomlout_oomp_project_bot_v_2 (continued)

## KiCad design projects/libresolar_mppt_2420_rc_mppt_2420_rc/current_version/working/working.kicad_pcb

File projects/libresolar_mppt_2420_rc_mppt_2420_rc/current_version/working/readme.md:

# mppt_2420_rc
 
## summary 
* id: libresolar_mppt_2420_rc_mppt_2420_rc
* user: libresolar
* name: mppt_2420_rc
* board: mppt_2420_rc
* repo: https://github.com/LibreSolar/mppt-2420-rc
* src_file_repo_kicad_pcb: kicad/mppt-2420-rc.kicad_pcb
* src_file_repo_kicad_pcb_link: https://github.com/LibreSolar/mppt-2420-rc/tree/master/kicad/mppt-2420-rc.kicad_pcb

* src_file_repo_sch: 
* src_file_repo_sch_link: https://github.com/LibreSolar/mppt-2420-rc/tree/master/
* full details link: https://github.com/oomlout/oomlout_oomp_project_bot_v_2/tree/main/projects/libresolar_mppt_2420_rc_mppt_2420_rc/current_version/working

Board: 4 copper layers, 67.7 x 86.4 mm, 120 parts (97 on the bottom side), 71 nets.

Parts:
C1, C2: 560µF; CP_Radial_D18.0mm_P7.50mm
C3, C18, C40: 1µF; C_0805_2012
C4: 100nF; C_0805_2012
C5: 820µF; CP_Radial_D10.0mm_P5.00mm
C6, C15: 1nF; C_0603_1608
C7, C9, C10, C11, C20, C22, C29, C30, C31, C32, C36, C48: 100nF; C_0603_1608
C8, C14, C16, C17, C34: 10nF; C_0603_1608
C12, C33, C39, C41, C49: 2.2µF; C_0603_1608
C19: 4.7µF; C_1210_3225
C21, C23: 10µF; C_0805_2012
C44: 0.22µF; C_Rect_L7.2mm_W3.5mm_P5.00mm_FKS2_FKP2_MKS2_MKP2
D1: SS16FP; D_PowerDI-123
D2, D3: NRVTS260ESFT1G; D_SOD-123
D5, D9, D11: 12V; D_SOT-23_ANK
D7, D14, D15: SS14FL; D_SOD-123
D8: 2.5V; D_SOD-123
D10, D16: 1N4148; D_SOD-123
F1: 25A; NULL
F2, F3: 600mA; Fuse_1206_3216Metric
FID1, FID2: Fiducial; Fiducial_0.7mm
HS1: Heatsink; Fischer_Elektronik_SK573_37,5
J1: MKDS 5/ 3-9,5; Phoenix_Contact_MKDS_5-3-9,5
J2: MKDS 5/ 2-9,5; Phoenix_Contact_MKDS_5-2-9,5
J3, J4: 8P8C; RJ45_8P8C
J5: Phoenix Contact MC 1,5; Phoenix_Contact_MC_1,5_2-G-3,81
J6: Conn_01x02; PinHeader_1x02_P2.54mm_Vertical
J7: UEXT; Box_Header_2x05x2.54mm_Straight
JP1: Jumper_NC_Small; PinHeader_1x02_P2.54mm_Vertical
L1: 33µH; L-FERYSTER-DTMSS-27
L2: 4.7µH; L_0805_2012Metric
L3: 47µH; Bourns_SRN6045TA
LED1: red; LED_D3.0mm
LOGO1: LIBRE_SOLAR; LIBRESOLAR_LOGO
LOGO2: OPEN_HARDWARE; OSHW-Logo_5.7x6mm_SilkScreen
NT1, NT2: Net-Tie_2; NetTie-2_SMD_Pad0.5mm
Q1, Q2, Q8: IPP045N10N3G; TO-220-3_Vertical
Q9: DMP10H4D2S; SOT-23
R1, R2, R3, R5: 3R3; R_0805_2012
R4: 2R2; R_1206_3216
R6: 2m; R_Bourns_CRE2512
R7, R24, R39, R41, R45, R64, R65, R66: 10k; R_0603_1608
R8, R10, R14, R20, R21: 2.2k; R_0603_1608
R9, R11: 68k; R_0603_1608
R12: 0R; R_0603_1608
R13, R17: 100k; R_0603_1608
R15, R42: 1k; R_0603_1608
R18: 5.6k; R_0603_1608
R22: 120R; R_1206_3216
R23, R60: 33k; R_0603_1608
R40: 100R; R_0603_1608
R56: 1M; R_0603_1608
RT1: 10k; R_0603_1608
RV2: 82V; RV_Disc_D12mm_W4.3mm_P7.5mm
SWD1: ST_Nucleo_SWD; PinHeader_1x05_P2.54mm_Vertical
T2, T6, T10: MMBT3904; SOT-23
TP4: 12V; TestPoint_Pad_D1.0mm
U1: LM5107; SOIC-8_3.9x4.9mm_Pitch1.27mm
U2: STM32G431CBTx; LQFP-48_7x7mm_P0.5mm
U3: TLV9001; SOT-23-5
U4: LMR16006X; SOT-23-6
U5: TCAN334; SOIC-8_3.9x4.9mm_Pitch1.27mm
U6: 24AA32; SOT-23-5
XF1: ATO blade fuse; Keystone-Fuse-3557-2
Y1: 8MHz; Resonator_Murata_CSTNE

Connections:
+3V3: C7.1, C11.1, C21.1, C22.1, C23.1, C30.1, C31.1, C32.1, C33.1, J7.1, L3.2, R20.2, R21.2, R23.1, R40.2, SWD1.1, U2.1, U2.24, U2.36, U2.48, U3.5, U5.3, U6.4
+12V: C12.1, C41.1, R3.2, R12.1, T10.2, TP4.1, U1.1
/BAT+: C8.1, J2.1, XF1.2
/CAN bus/CAN_GND: D3.2, J3.3, J3.7, J4.3, J4.7
/CAN bus/CAN_H: J3.1, J4.1, JP1.1, U5.7
/CAN bus/CAN_L: J3.2, J4.2, R22.2, U5.6
/CAN bus/CAN_RX: U2.33, U5.4
/CAN bus/CAN_STB: U2.28, U5.8
/CAN bus/CAN_TX: U2.34, U5.1
/CAN bus/CAN_V+1: F2.1, J3.4, J3.5
/CAN bus/CAN_V+2: F3.1, J4.4, J4.5
/DC/DC/HS_DRV: D14.1, R1.2, U1.7
/DC/DC/LS_DRV: D7.2, D15.1, R2.2, U1.5
/DC/DC/PWM_HS: U1.2, U2.30
/DC/DC/PWM_LS: U1.3, U2.27
/DC/DC/SHUNT_N: NT1.2, R10.1
/DC/DC/SHUNT_P: NT2.2, R8.1
/DC/DC/SW_NODE: C10.2, L1.1, Q1.3, Q2.2, R4.2, U1.6
/DCDC_HV+: C1.1, C2.1, C3.1, C4.1, C17.1, D11.1, J1.1, Q1.2, Q9.2, R13.1, R60.2, R65.2, RV2.1
/DCDC_HV-: C17.2, J1.2, Q8.2, R41.1, RV2.2
/MCU/ADC1_IN2: C9.1, R7.2, RT1.1, U2.9
/MCU/ADC1_IN11: D8.1, R41.2, T6.1, U2.26
/MCU/ADC1_IN12: C16.1, R17.2, R18.1, U2.17
/MCU/ADC1_IN15: C14.1, R13.2, R14.1, U2.16
/MCU/ADC2_IN1: C15.1, R15.2, U2.8
/MCU/DAC1: R9.1, U2.12
/MCU/I2C1_SCL: J7.5, R20.1, U2.39, U6.1
/MCU/I2C1_SDA: J7.6, R21.1, U2.44, U6.3
/MCU/LED_PWR: R42.2, U2.29
/MCU/OPAMP2_VINM: R10.2, R11.1, U2.13, U3.4
/MCU/OPAMP2_VINP: R8.2, R9.2, U2.15, U3.3
/MCU/OPAMP2_VOUT: R11.2, R15.1, U2.14, U3.1
/MCU/OSC_IN: U2.5, Y1.3
/MCU/OSC_OUT: U2.6, Y1.1
/MCU/SPI1_MISO: J7.7, U2.41
/MCU/SPI1_MOSI: J7.8, U2.42
/MCU/SPI1_SCK: J7.9, U2.40
/MCU/SPI1_SSEL: J7.10, U2.43
/MCU/SWCLK: SWD1.2, U2.38
/MCU/SWDIO: SWD1.4, U2.37
/MCU/TEMP_BAT: C36.1, J5.1, R39.2, U2.25
/MCU/USART1_RX: J6.2, U2.32
/MCU/USART1_TX: J6.1, U2.31
/MCU/USART2_RX: J7.4, U2.11
/MCU/USART2_TX: J7.3, U2.10
/MCU/~RESET: C29.1, SWD1.5, U2.7
/Power Supply/SMPS_SUPPLY: C18.1, C40.1, D10.1, L2.1, Q9.3, R64.2, T10.3
GND: C5.2, C7.2, C8.2, C9.2, C11.2, C14.2, C15.2, C16.2, C18.2, C19.2, C21.2, C22.2, C23.2, C29.2, C30.2, C31.2, C32.2, C33.2, C34.2, C36.2, C39.2, C40.2, C41.2, C44.1, C48.2, C49.2, D1.2, D3.1, D5.2, D9.2, J2.2, J5.2, J7.2, LED1.1, NT2.1, R6.1, R14.2, R18.2, R24.2, RT1.2, SWD1.3, U2.19, U2.23, U2.35, U2.45, U2.47, U3.2, U4.2, U5.2, U6.2, U6.5, Y1.2
GNDPWR: C1.2, C2.2, C3.2, C4.2, C6.2, C12.2, D8.2, J1.3, NT1.1, Q2.3, Q8.3, R6.2, R56.2, T6.2, U1.4
unnamed: C6.1, R4.1
unnamed: C10.1, R5.2
unnamed: C19.1, L2.2, U4.4, U4.5
unnamed: C20.1, U4.1
unnamed: C20.2, D1.1, L3.1, U4.6
unnamed: D2.1, F2.2, F3.2
unnamed: D5.1, R64.1, T10.1
unnamed: D7.1, R12.2, R45.1
unnamed: D9.1, R60.1, T2.1
unnamed: D11.2, Q9.1, R65.1, R66.2
unnamed: D14.2, Q1.1, R1.1
unnamed: D15.2, Q2.1, R2.1
unnamed: D16.1, R5.1, U1.8
unnamed: D16.2, R3.1
unnamed: JP1.2, R22.1
unnamed: LED1.2, R42.1
unnamed: Q8.1, R45.2, R56.1, T6.3
unnamed: R23.2, R24.1, U4.3
unnamed: R66.1, T2.3
VBUS: C5.1, C44.2, D2.2, D10.2, L1.2, R17.1, T2.2, XF1.1
VDDA: C34.1, C39.1, R40.1, U2.21
VREF: C48.1, C49.1, R7.1, R39.1, U2.20

## KiCad design projects/libresolar_pwm_2420_lus_pwm_2420_lus/current_version/working/working.kicad_pcb

File projects/libresolar_pwm_2420_lus_pwm_2420_lus/current_version/working/readme.md:

# pwm_2420_lus
 
## summary 
* id: libresolar_pwm_2420_lus_pwm_2420_lus
* user: libresolar
* name: pwm_2420_lus
* board: pwm_2420_lus
* repo: https://github.com/LibreSolar/pwm-2420-lus
* src_file_repo_kicad_pcb: kicad/pwm-2420-lus.kicad_pcb
* src_file_repo_kicad_pcb_link: https://github.com/LibreSolar/pwm-2420-lus/tree/master/kicad/pwm-2420-lus.kicad_pcb

* src_file_repo_sch: 
* src_file_repo_sch_link: https://github.com/LibreSolar/pwm-2420-lus/tree/master/
* full details link: https://github.com/oomlout/oomlout_oomp_project_bot_v_2/tree/main/projects/libresolar_pwm_2420_lus_pwm_2420_lus/current_version/working

Board: 2 copper layers, 90.0 x 85.0 mm, 128 parts (3 on the bottom side), 73 nets.

Parts:
C1, C2, C10, C11, C12, C25, C31, C32, C39: 100n; C_0805_2012
C3, C4, C9, C17, C18, C27, C34: 10n; C_0805_2012
C5, C15, C22, C33: 4.7u; C_0805_2012
C6: 180u; CP_Radial_D8.0mm_P3.50mm
C7: 330p; C_0805_2012
C8: 470u; CP_Radial_D8.0mm_P3.50mm
C13, C14: 1u; C_0805_2012
D1, D3, D8: 12V; D_SOT-23_ANK
D2, D9: SS14FL; D_SOD-123F
D7: 1N4148; D_SOD-123
J1, J2, J3: MKDS 5/ 2-9,5; Phoenix_Contact_MKDS_5-2-952
J4: UEXT; Box_Header_2x05x2.54mm_Straight
J5: USB_A; USB_A_Wuerth_61400416021_Horizontal
J6: PWR_12V; JST_XH_B02B-XH-A_1x02_P2.50mm_Vertical
J7: 6P6C; RJ25_6P6C_TabUp
J8: ST_Nucleo_SWD_5p; PinHeader_1x05_P2.54mm_Vertical
L3: 150uH; L_Radial_D12.0mm_P5.00mm_Fastron_11P
LED1, LED2, LED3: yellow; LED_0603_D3.0mm
LED4, LED5: green; LED_0603_D3.0mm
LOGO1: LIBRE_SOLAR; LIBRESOLAR_LOGO
LOGO2: OPEN_HARDWARE; OSHW-Logo_5.7x6mm_SilkScreen
MK1, MK2, MK3, MK4: Mounting_Hole; MountingHole_3.2mm_M3_Pad
Q1, Q2, Q3: PSMN7R5-60YLX; 5X6_MOSFET
Q6, Q7, Q8: AOT266L; TO-220-3_Horizontal_TabUp
R1, R4, R5, R7, R9, R12, R13, R14, R18, R20, R30, R45, R47: 2.2k; R_0805_2012
R2, R22, R28: 39k; R_0805_2012
R3, R10, R16, R19, R21: 68k; R_0805_2012
R6, R17: 2m; R_Bourns_CRE2512
R8, R33, R34, R43, R44: 470; R_0805_2012
R11, R15, R25, R37, R42, R46, R48, R49, R51: 120k; R_0805_2012
R23, R24, R41: 8.2k; R_0805_2012
R26, R27, R29, R31, R35, R39, R40: 12k; R_0805_2012
R32: 100R; R_0805_2012
R36: 0.33; R_1206_3216
R38: 0R; R_0805_2012
RT1: 10k; R_0805_2012
RT2: 200mA; R_1206_3216
RV1: 56V; RV_Disc_D12mm_W4.3mm_P7.5mm
T1, T3, T4, T5, T6: MMBT3904; SOT-23
T2: MMBT3906; SOT-23
TP1: G_PWM; TestPoint_Pad_D1.0mm
TP2: G_LOAD; TestPoint_Pad_D1.0mm
TP4: I_SOLAR; TestPoint_Pad_D1.0mm
TP5: I_LOAD; TestPoint_Pad_D1.0mm
TP7: 5V; TestPoint_Pad_D1.0mm
TP8: 12V; TestPoint_Pad_D1.0mm
TP9: 3V3; TestPoint_Pad_D1.0mm
U1: STM32L072CZTx; LQFP-48_7x7mm_P0.5mm
U2: TLV9002; SOIC-8_3.9x4.9mm_Pitch1.27mm
U3: MC34063AD; SOIC-8_3.9x4.9mm_P1.27mm
U4: D1213A-04SO; SOT-23-6
U5: LP2950-3.3_TO252; TO-252-2

Connections:
+3V3: C1.1, C2.1, C15.1, C31.1, C32.1, C33.1, J4.1, J8.1, R5.2, R15.1, R30.2, R32.2, R42.1, RT2.2, TP9.1, U1.1, U1.24, U1.36, U1.48, U2.8, U5.3
+5V: C8.1, J5.1, L3.2, R28.1, TP7.1
+12V: C12.1, C22.1, D3.2, R8.1, R11.2, R16.2, T5.2, TP8.1
/MCU/BOOT0: C11.1, R7.2, R46.1, R47.2, U1.44
/MCU/BUTTON: R7.1, U1.25
/MCU/I2C1_SCL: J4.5, R30.1, U1.42
/MCU/I2C1_SDA: J4.6, R5.1, U1.43
/MCU/LED_A: R33.1, U1.26
/MCU/LED_B: LED1.1, LED2.2, LED4.2, LED5.1, U1.27
/MCU/LED_C: LED3.1, R34.1, U1.28
/MCU/RX: J7.2, R43.1, U4.6
/MCU/SPI1_MISO: J4.7, U1.32
/MCU/SPI1_MOSI: J4.8, U1.33
/MCU/SPI1_SCK: J4.9, U1.39
/MCU/SSEL: J4.10, U1.38
/MCU/SWCLK: J8.2, U1.37
/MCU/SWDIO: J8.4, U1.34
/MCU/TEMP_EXT: J7.5, R23.2, R45.1, RT1.1, U4.1
/MCU/TEMP_INT_PD: RT1.2, U1.29
/MCU/TX: J7.3, R44.1, U4.4
/MCU/USART1_RX: R42.2, R43.2, U1.31
/MCU/USART1_TX: R44.2, U1.30
/MCU/USART2_RX: J4.4, U1.13
/MCU/USART2_TX: J4.3, U1.12
/MCU/~RESET: C39.1, J8.5, U1.7
/PWM power stage/GQ12: D1.1, Q1.G, Q2.G, Q6.1, Q7.1, R2.1, T2.3, T4.3, TP1.1
/PWM power stage/L_SHUNT+: Q3.S, Q8.3, R17.2, R18.2, T1.2
/PWM power stage/S_SHUNT-: Q2.D, Q7.2, R4.2, R6.1
/Power Supply/BAT_INPUT: C6.1, C13.1, D2.1, R31.2, R35.2, R36.2, T5.3, T6.3, U3.6
BAT+: C27.1, D2.2, J1.1, J2.1, J3.1, J6.1, R25.1, R39.1, RV1.1
DAC: R3.2, R19.1, U1.14
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C9.2, C10.2, C11.2, C12.2, C13.2, C14.2, C15.2, C17.2, C18.2, C22.2, C31.2, C32.2, C33.2, C34.2, C39.2, D8.2, J3.2, J4.2, J6.2, J7.4, J8.3, R1.2, R6.2, R17.1, R20.2, R26.2, R27.2, R41.1, R46.2, R49.2, T3.2, U1.8, U1.23, U1.35, U1.47, U2.4, U4.2, U5.2
I_LOAD: C4.1, R22.2, R40.2, TP5.1, U1.15
I_LOAD_COMP: R40.1, R41.2, U1.40
I_SOLAR: C3.1, R14.2, TP4.1, U1.16
LOAD-: C6.2, C7.2, C8.2, C25.2, C27.2, D9.2, J2.2, J5.4, Q3.D, Q8.2, R29.2, U3.4
LOAD_DIS: R13.2, R15.2, U1.20
unnamed: C7.1, U3.3
unnamed: C10.1, J7.1, RT2.1, U4.5
unnamed: C14.1, T6.2, U5.1
unnamed: C25.1, J5.5
unnamed: D1.2, Q1.S, Q2.S, Q6.3, Q7.3, R2.2, T4.2
unnamed: D3.1, R35.1, T6.1
unnamed: D7.1, R28.2, R29.1, U3.5
unnamed: D8.1, R31.1, T5.1
unnamed: D9.1, L3.1, U3.2
unnamed: J5.2, R38.2
unnamed: J5.3, R38.1
unnamed: J7.6, R47.1, U4.3
unnamed: LED1.2, LED2.1, LED3.2, R33.2
unnamed: LED4.1, LED5.2, R34.2
unnamed: Q3.G, Q8.1, R9.2, TP2.1
unnamed: R1.1, R3.1, U2.3
unnamed: R8.2, T2.2
unnamed: R4.1, R10.1, U2.2
unnamed: R10.2, R14.1, U2.1
unnamed: R11.1, R51.2, T2.1
unnamed: R12.1, R49.1, T3.1
unnamed: R13.1, T1.1
unnamed: R9.1, R16.1, T1.3
unnamed: R18.1, R19.2, U2.5
unnamed: R20.1, R21.1, U2.6
unnamed: R21.2, R22.1, U2.7
unnamed: R36.1, U3.1, U3.7, U3.8
unnamed: R48.1, T4.1
unnamed: R51.1, T3.3
PWM: R12.2, U1.19
SOLAR-: J1.2, Q1.D, Q6.2, R37.1, R39.2, R48.2, RV1.2
T_BAT: C9.1, R45.2, U1.17
USB_PWR_DIS: D7.2, U1.41
VDDA: C5.1, C34.1, R23.1, R24.1, R32.1, U1.9
V_BAT: C18.1, R25.2, R27.1, U1.10
V_SOLAR: C17.1, R24.2, R26.1, R37.2, U1.11
