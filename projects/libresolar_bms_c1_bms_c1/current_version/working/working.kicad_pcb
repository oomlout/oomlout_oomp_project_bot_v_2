# Repository oomlout/oomlout_oomp_project_bot_v_2 (continued)

## KiCad design projects/libresolar_mppt_2420_hc_mppt_2420_hc/current_version/working/working.kicad_pcb

File projects/libresolar_mppt_2420_hc_mppt_2420_hc/current_version/working/readme.md:

# mppt_2420_hc
 
## summary 
* id: libresolar_mppt_2420_hc_mppt_2420_hc
* user: libresolar
* name: mppt_2420_hc
* board: mppt_2420_hc
* repo: https://github.com/LibreSolar/mppt-2420-hc
* src_file_repo_kicad_pcb: kicad/mppt-2420-hc.kicad_pcb
* src_file_repo_kicad_pcb_link: https://github.com/LibreSolar/mppt-2420-hc/tree/main/kicad/mppt-2420-hc.kicad_pcb

* src_file_repo_sch: 
* src_file_repo_sch_link: https://github.com/LibreSolar/mppt-2420-hc/tree/main/
* full details link: https://github.com/oomlout/oomlout_oomp_project_bot_v_2/tree/main/projects/libresolar_mppt_2420_hc_mppt_2420_hc/current_version/working

Board: 4 copper layers, 100.0 x 100.0 mm, 172 parts (5 on the bottom side), 94 nets.

Parts:
C1, C2: 390µF; CP_Radial_D18.0mm_P7.50mm
C3, C18: 1µF; C_0805_2012
C4: 100nF; C_0805_2012
C5, C27: 680µF; CP_Radial_D10.0mm_P5.00mm
C6: 2.2nF; C_0603_1608
C7, C9, C10, C13, C20, C22, C24, C28, C29, C30, C31, C32, C48: 100nF; C_0603_1608
C8, C14, C16, C17, C25, C26, C34, C37, C45: 10nF; C_0603_1608
C11, C15: 1nF; C_0603_1608
C12, C33, C39, C49: 2.2µF; C_0603_1608
C19: 4.7µF; C_1210_3225
C21, C23: 10µF; C_0805_2012
C40: 1µF; C_0603_1608
C41: 4.7µF; C_0603_1608
C42, C44: 0.22µF; C_Rect_L7.2mm_W3.5mm_P5.00mm_FKS2_FKP2_MKS2_MKP2
D1: SS16FP; D_PowerDI-123
D2, D6: NRVTS260ESFT1G; D_SOD-123
D3, D5: 12V; D_SOT-23_ANK
D4: BAS70-04; SOT-23
D7, D14, D15: SS14FL; D_SOD-123
D9: 47V; D_SOT-23_ANK
D10, D16: 1N4148; D_SOD-123
F1: 25A; NULL
F2, F3: 500mA; Fuse_1206_3216Metric
FID1, FID2, FID3: Fiducial; Fiducial_0.7mm
J1, J2, J3: MKDS 5/ 2-9,5; Phoenix_Contact_MKDS_5-2-9,5
J4, J5: 8P8C; RJ45_8P8C
J6: JST PH; JST_PH_B3B-PH-K_1x03_P2.00mm_Vertical
J7: UEXT; Box_Header_2x05x2.54mm_Straight
JP1: Jumper_NC_Small; PinHeader_1x02_P2.54mm_Vertical
L1: 53µH; Inductor_Toroid_D32.8mm_4mm2
L2: 4.7µH; L_0805_2012Metric
L3: 47µH; Bourns_SRN6045TA
LED1, LED2: LED_Dual_PLCC4; LED_Avago_PLCC4_3.2x2.8mm_CW
LOGO1: LIBRE_SOLAR; LIBRESOLAR_LOGO
LOGO2: OPEN_HARDWARE; OSHW-Logo_5.7x6mm_SilkScreen
MK1, MK2, MK3, MK4: Mounting_Hole; MountingHole_3.2mm_M3
P1: CONN_01X02; PinHeader_1x02_P2.54mm_Vertical
Q1, Q2, Q3, Q7: IPA045N10N3G; TO-220-3_Horizontal_BottomHeatsink
Q4: BUK98180-100A; SOT-223-3_TabPin2
R1, R2, R3, R5: 3R3; R_0805_2012
R4, R12: 4R7; R_1206_3216
R6, R62: 2m; R_Bourns_CRE2512
R7, R16, R19, R24, R49, R59, R64: 10k; R_0603_1608
R8, R9: 10R; R_0603_1608
R10, R25, R26, R29, R66: 1k; R_0603_1608
R11: 120R; R_1206_3216
R13, R17, R22, R30, R58, R60, R65: 100k; R_0603_1608
R14, R20, R21, R31, R44, R57: 2.2k; R_0603_1608
R15, R56, R61: 1M; R_0603_1608
R18: 5.6k; R_0603_1608
R23: 33k; R_0603_1608
R27, R28, R32, R40: 47R; R_0603_1608
R50: 8.2k; C_0603_1608
RT1: 10k; C_Disc_D3.8mm_W2.6mm_P2.50mm
RV2: 82V; RV_Disc_D12mm_W4.3mm_P7.5mm
SWD1: ST_Nucleo_SWD; PinHeader_1x05_P2.54mm_Vertical
T1, T2, T3, T5, T10: BC846B; SOT-23
T4: BC856B; SOT-23
TP1, TP2, TP3, TP4, TP5, TP6, TP7, TP8, TP9, TP10, TP11, TP12, TP13, TP14, TP15, TP16, TP17, TP18, TP19, TP20, TP21, TP22: 1.5mm; TestPoint_Pad_D1.5mm
U1: LM5107; SOIC-8_3.9x4.9mm_Pitch1.27mm
U2: STM32G431CBTx; LQFP-48_7x7mm_P0.5mm
U3, U5: INA186; SOT-363_SC-70-6
U4: LMR16006X; SOT-23-6
U6: W25Q80DVS; SOIC-8_3.9x4.9mm_Pitch1.27mm
U7: TCAN334; SOIC-8_3.9x4.9mm_Pitch1.27mm
XF1: Fuse_Holder; Keystone-Fuse-3557-2
Y1: 8MHz; Resonator_Murata_CSTNE

Connections:
+3V3: C7.1, C13.1, C21.1, C22.1, C23.1, C28.1, C30.1, C31.1, C32.1, C33.1, J7.1, L3.2, R7.1, R20.2, R21.2, R23.1, R31.2, R40.2, SWD1.1, TP11.1, U2.1, U2.24, U2.36, U2.48, U3.3, U5.3, U6.3, U6.7, U6.8, U7.3
+12V: C12.1, C41.1, D4.1, R3.2, T10.2, TP4.1, U1.1
/BAT+: C8.1, J2.1, XF1.2
/CAN/CAN_PWR1: F2.1, J4.4, J4.5
/CAN/CAN_PWR2: F3.1, J5.4, J5.5
/CAN/CAN_RX: TP19.1, U2.33, U7.4
/CAN/CAN_STB: TP18.1, U2.25, U7.8
/CAN/CAN_TX: TP17.1, U2.34, U7.1
/CAN_GND: D6.2, J4.3, J4.7, J5.3, J5.7
/CAN_H: J4.1, J5.1, JP1.1, U7.7
/CAN_L: J4.2, J5.2, R11.2, U7.6
/DC/DC/HS_DRV: D14.1, R1.2, U1.7
/DC/DC/LS_DRV: D7.2, D15.1, R2.2, U1.5
/DC/DC/PWM_HS: TP21.1, U1.2, U2.30
/DC/DC/PWM_LS: TP22.1, U1.3, U2.2
/DC/DC/SHUNT_DCDC_P: C42.1, L1.2, R6.2, R8.1
/DC/DC/SW_NODE: C6.1, C10.2, L1.1, Q1.3, Q2.2, U1.6
/DCDC_HV+: C1.1, C2.1, C3.1, C4.1, C17.1, J1.1, Q1.2, Q4.2, R13.1, R60.2, RV2.1, TP7.1
/DCDC_HV-: C17.2, J1.2, Q3.2, RV2.2, TP5.1
/LOAD+: C37.1, D3.2, J3.1, Q7.3, R61.2, TP16.1
/Load switch/CP_OUT: C24.1, D4.2, R58.1, R65.2, TP10.1
/MCU/ADC1_IN11: C9.1, R7.2, RT1.1, TP15.1, U2.26
/MCU/ADC1_IN12: C16.1, R17.2, R18.1, TP6.1, U2.17
/MCU/ADC1_IN15: C14.1, R13.2, R14.1, TP3.1, U2.16
/MCU/ADC12_IN1: C15.1, R10.2, TP1.1, U2.8
/MCU/ADC12_IN2: C26.1, R44.2, TP2.1, U2.9
/MCU/COMP2_INP: C45.1, R49.1, R50.2, U2.15
/MCU/DAC1: U2.12, U3.1
/MCU/GPIOB_2: R57.1, U2.18
/MCU/GPIOC_14: LED1.2, LED1.3, TP13.1, U2.3
/MCU/GPIOC_15: LED2.2, LED2.3, TP20.1, U2.4
/MCU/I2C1_SCL: J7.5, R20.1, U2.39
/MCU/I2C1_SDA: J7.6, R21.1, U2.44
/MCU/OSC_IN: U2.5, Y1.3
/MCU/OSC_OUT: U2.6, Y1.1
/MCU/SPI1_MISO: J7.7, U2.41
/MCU/SPI1_MOSI: J7.8, U2.42
/MCU/SPI1_SCK: J7.9, U2.40
/MCU/SPI1_SSEL: J7.10, U2.43
/MCU/SPI2_CS: R31.1, U2.13, U6.1
/MCU/SPI2_MISO: R28.1, U2.28
/MCU/SPI2_MOSI: R27.1, U2.29
/MCU/SPI2_SCK: R32.2, U2.27
/MCU/SWCLK: SWD1.2, U2.38
/MCU/SWDIO: SWD1.4, U2.37
/MCU/TIM16_CH1: R29.2, U2.14
/MCU/TIM17_CH1: R26.2, U2.46
/MCU/USART1_RX: P1.2, U2.32
/MCU/USART1_TX: P1.1, U2.31
/MCU/USART2_RX: J7.4, U2.11
/MCU/USART2_TX: J7.3, U2.10
/MCU/~RESET: C29.1, SWD1.5, U2.7
/MEAS_LV+: J6.3, Q7.2, R62.1, U5.5
/PWR_INFO: J6.1, U2.22
/Power supply/CP_PWM: R15.2, R16.2, U2.45
/Power supply/CP_SW: C25.2, T3.2, T4.2
/Power supply/SUPPLY_INPUT: C18.1, C40.1, D10.1, L2.1, Q4.3, R64.2, T10.3, TP9.1
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C7.2, C8.2, C9.2, C12.2, C13.2, C14.2, C15.2, C16.2, C18.2, C19.2, C21.2, C22.2, C23.2, C26.2, C27.2, C28.2, C29.2, C30.2, C31.2, C32.2, C33.2, C34.2, C37.2, C39.2, C40.2, C41.2, C42.2, C44.1, C45.2, C48.2, C49.2, D1.2, D5.2, D6.1, D9.2, J2.2, J3.2, J6.2, J7.2, Q2.3, Q3.3, R4.1, R12.1, R14.2, R15.1, R18.2, R24.2, R30.1, R50.1, R56.2, RT1.2, SWD1.3, T1.2, T4.3, T5.2, U1.4, U2.19, U2.23, U2.35, U2.47, U3.2, U4.2, U5.1, U5.2, U6.4, U7.2, Y1.2
unnamed: C6.2, R4.2, R12.2
unnamed: C10.1, R5.2
unnamed: C11.1, R8.2, U3.4
unnamed: C11.2, R9.2, U3.5
unnamed: C19.1, L2.2, U4.4, U4.5
unnamed: C20.1, U4.1
unnamed: C20.2, D1.1, L3.1, U4.6
unnamed: C25.1, D4.3
unnamed: D2.1, F2.2, F3.2
unnamed: D3.1, Q7.1, R58.2, R59.2, R61.1
unnamed: D5.1, R64.1, T10.1
unnamed: D7.1, Q3.1, R56.1
unnamed: D9.1, Q4.1, R60.1, R66.2
unnamed: D14.2, Q1.1, R1.1
unnamed: D15.2, Q2.1, R2.1
unnamed: D16.1, R5.1, U1.8
unnamed: D16.2, R3.1
unnamed: JP1.2, R11.1
unnamed: LED1.1, LED1.4, R29.1, TP12.1
unnamed: LED2.1, LED2.4, R26.1, TP14.1
unnamed: R10.1, U3.6
unnamed: R16.1, T1.1
unnamed: R19.2, R65.1, T2.1
unnamed: R22.1, R25.1, T1.3
unnamed: R23.2, R24.1, U4.3
unnamed: R25.2, T3.1, T4.1
unnamed: R27.2, U6.5
unnamed: R28.2, U6.2
unnamed: R30.2, R32.1, U6.6
unnamed: R44.1, R49.2, U5.6
unnamed: R57.2, T5.1
unnamed: R59.1, T5.3
unnamed: R66.1, T2.3
VBUS: C5.1, C24.2, C27.1, C44.2, D2.2, D10.2, R6.1, R9.1, R17.1, R19.1, R22.2, R62.2, T2.2, T3.3, TP8.1, U5.4, XF1.1
VDDA: C34.1, C39.1, R40.1, U2.21
VREF: C48.1, C49.1, U2.20

## KiCad design projects/libresolar_mppt_2420_hpx_mppt_2420_hpx/current_version/working/working.kicad_pcb

File projects/libresolar_mppt_2420_hpx_mppt_2420_hpx/current_version/working/readme.md:

# mppt_2420_hpx
 
## summary 
* id: libresolar_mppt_2420_hpx_mppt_2420_hpx
* user: libresolar
* name: mppt_2420_hpx
* board: mppt_2420_hpx
* repo: https://github.com/LibreSolar/mppt-2420-hpx
* src_file_repo_kicad_pcb: kicad/mppt-2420-hpx.kicad_pcb
* src_file_repo_kicad_pcb_link: https://github.com/LibreSolar/mppt-2420-hpx/tree/master/kicad/mppt-2420-hpx.kicad_pcb

* src_file_repo_sch: 
* src_file_repo_sch_link: https://github.com/LibreSolar/mppt-2420-hpx/tree/master/
* full details link: https://github.com/oomlout/oomlout_oomp_project_bot_v_2/tree/main/projects/libresolar_mppt_2420_hpx_mppt_2420_hpx/current_version/working

Board: 4 copper layers, 120.0 x 100.0 mm, 191 parts (7 on the bottom side), 116 nets.

Parts:
C1, C2: 560µF; CP_Radial_D18.0mm_P7.50mm
C3, C18: 1µF; C_0805_2012
C4: 100nF; C_0805_2012
C5: 820µF; CP_Radial_D10.0mm_P5.00mm
C6: 1nF; C_0603_1608
C7, C8, C14, C16, C17, C24, C26, C27, C34, C37, C38, C45: 10nF; C_0603_1608
C9, C10, C13, C15, C20, C22, C25, C28, C29, C30, C31, C32, C35, C36, C43, C48: 100nF; C_0603_1608
C11: 100pF; C_0603_1608
C12, C33, C39, C49: 2.2µF; C_0603_1608
C19: 4.7µF; C_1210_3225
C21, C23, C46: 10µF; C_0805_2012
C40: 1µF; C_0603_1608
C41: 4.7µF; C_0603_1608
C42, C44: 0.22µF; C_Rect_L7.2mm_W3.5mm_P5.00mm_FKS2_FKP2_MKS2_MKP2
C47: 2.2µF; C_0805_2012
D1: SS16FP; D_PowerDI-123
D2, D3, D5, D9, D11: 12V; D_SOT-23_ANK
D4: BAT54S; SOT-23
D6, D10, D16: 1N4148; D_SOD-123
D7, D14, D15: SS14FL; D_SOD-123
F1: 25A; Keystone-Fuse-3557-2
F2: 200mA; R_1206_3216
FID1, FID2: Fiducial; Fiducial_0.7mm
J1, J2, J3, J4: MKDS 5/ 2-9,5; Phoenix_Contact_MKDS_5-2-9,5
J5: Phoenix Contact MC 1,5; Phoenix_Contact_MC_1,5_2-G-3,81
J6: JST XH; JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical
J7, J9: UEXT; Box_Header_2x05x2.54mm_Straight
J8: USB Micro B; USB_Micro-B_10103594-0001LF
J10: CommsExt_2x8
J11: Conn_01x06; PinHeader_1x06_P2.54mm_Vertical
L1: 33µH; L-FERYSTER-DTMSS-27
L2: 4.7µH; L_0805_2012Metric
L3: 47µH; Bourns_SRN6045TA
LED1: red; LED_0603_1608Metric
LOGO1: LIBRE_SOLAR; LIBRESOLAR_LOGO
LOGO2: OPEN_HARDWARE; OSHW-Logo_5.7x6mm_SilkScreen
MK1, MK2, MK3, MK4: Mounting_Hole; MountingHole_3.2mm_M3
Q1, Q2, Q5, Q6, Q7, Q8: IPA045N10N3G; TO-220-3_Horizontal_BottomHeatsink
Q3, Q4: MMBT3904; SOT-23
Q9: DMP10H4D2S; SOT-23
R1, R2, R3, R5: 3R3; R_0805_2012
R4: 2R2; R_1206_3216
R6, R51, R62: 2m; R_Bourns_CRE2512
R7, R14, R16, R19, R24, R39, R59, R63, R67, R68, R83: 10k; R_0603_1608
R8, R9: 10R; R_0603_1608
R10, R12, R15: ?; R_0603_1608
R11, R13, R17, R22, R58, R81: 100k; R_0603_1608
R18: 5.6k; R_0603_1608
R20, R21, R30, R31, R32, R34, R35, R43, R52, R54, R57: 2.2k; R_0603_1608
R23: 33k; R_0603_1608
R25, R29, R48, R53, R55: 120k; C_0603_1608
R26, R50: 8.2k; C_0603_1608
R27, R49: 12k; C_0603_1608
R28, R60, R64, R65, R66: 12k; R_0603_1608
R33, R36, R38, R47: 68k; C_0603_1608
R37: 39k; R_0603_1608
R40: 100R; R_0603_1608
R42, R46: 470R; R_0603_1608
R44: 2.2k; C_0603_1608
R56, R61: 1M; R_0603_1608
R85: 1k; R_0603_1608
RT1: 10k; R_0603_1608
RV1, RV2: 56V; RV_Disc_D12mm_W4.3mm_P7.5mm
SWD1: ST_Nucleo_SWD; PinHeader_1x06_P2.54mm_Vertical
T1, T2, T4, T5, T7, T8, T10: MMBT3904; SOT-23
T3, T9: MMBT3906; SOT-23
TEST: TestPoint_Pad_1.0x1.0mm
TP1: G_PWM; TestPoint_Pad_D1.0mm
TP2: I_LOAD; TestPoint_Pad_D1.0mm
TP3: I_SOLAR; TestPoint_Pad_D1.0mm
TP4: 12V; TestPoint_Pad_D1.0mm
U1: LM5107; SOIC-8_3.9x4.9mm_Pitch1.27mm
U2: STM32G431RBTx; LQFP-64_10x10mm_P0.5mm
U3: INA303A1; TSSOP-14_4.4x5mm_P0.65mm
U4: LMR16006X; SOT-23-6
U5: TLV9002; SOIC-8_3.9x4.9mm_Pitch1.27mm
U6: 24AA01; SOT-23-5
U7: ESP32-WROOM-32D; ESP32-WROOM-32
Y1: 8MHz; Resonator_Murata_CSTNE

Connections:
+3V3: C13.2, C21.1, C22.1, C23.1, C28.1, C30.1, C31.1, C32.1, C33.1, C43.1, C46.1, J7.1, J9.1, J10.16, J11.3, L3.2, R7.1, R11.2, R16.2, R19.2, R20.2, R21.2, R23.1, R31.2, R32.2, R39.1, R40.2, R68.2, SWD1.1, U2.1, U2.16, U2.32, U2.48, U2.64, U3.1, U5.8, U6.4, U7.2
+12V: C12.1, C25.1, C41.1, D4.1, R3.2, R46.1, R48.2, T10.2, TP4.1, U1.1
/Accessories/CAN_RX: J10.12, U2.61
/Accessories/CAN_TX: J10.11, U2.62
/Accessories/COM_I2C_SCL: J9.5, J10.14, SWD1.4, U2.49
/Accessories/COM_I2C_SDA: J9.6, J10.13, SWD1.2, U2.50
/Accessories/COM_MISO: J7.7, J9.7, J10.1, U2.57
/Accessories/COM_MOSI: J7.8, J9.8, J10.2, U2.58
/Accessories/COM_PWRI: J10.6, U2.36
/Accessories/COM_RX: J9.4, J10.10, U2.44, U7.27
/Accessories/COM_SCK: J7.9, J9.9, J10.3, U2.56
/Accessories/COM_SSEL: J9.10, J10.4, U2.54
/Accessories/COM_TX: J9.3, J10.9, U2.43, U7.28
/Accessories/DTR: J11.6, Q3.2, R67.2
/Accessories/FTDI_RX: J11.5, U7.35
/Accessories/FTDI_TX: J11.4, U7.34
/Accessories/GPIO0: Q3.3, U7.25
/Accessories/RESET: C47.1, Q4.3, R68.1, U7.3
/Accessories/RTS: J11.2, Q4.2, R63.2
/BAT+: C8.1, F1.2, J2.1
/DC/DC/HS_DRV: D14.1, R1.2, U1.7
/DC/DC/LS_DRV: D7.2, D15.1, R2.2, U1.5
/DC/DC/NOC_ALERT: R19.1, U2.11, U3.11
/DC/DC/POC_ALERT: R16.1, U2.2, U3.12
/DC/DC/PWM_HS: U1.2, U2.42
/DC/DC/PWM_LS: U1.3, U2.35
/DC/DC/SHUNT+: C42.1, L1.2, R6.2, R8.1
/DC/DC/SW_NODE: C10.2, L1.1, Q1.3, Q2.2, R4.2, U1.6
/DCDC_HV+: C1.1, C2.1, C3.1, C4.1, C17.1, D6.1, D11.1, J1.1, Q1.2, Q9.2, R13.1, R60.2, R65.2, RV2.1
/DCDC_HV-: C17.2, J1.2, Q8.2, RV2.2
/LOAD+: C37.1, D3.2, J3.1, Q7.3, R61.2
/LOAD-: C37.2, J3.2, R30.2, R62.1, U2.21
/LV switches/CP_OUT: C35.1, D4.2, R58.1
/LV switches/CP_PWM: R83.2, U2.38
/LV switches/CP_SW: C38.2, T8.2, T9.2
/LV switches/G_PWM: D2.1, Q5.1, Q6.1, R37.1, T1.3, T3.3, TP1.1
/LV switches/PWM_SW_EN: R52.2, U2.39
/LV switches/S_SHUNT-: Q6.2, R43.2, R51.1
/MCU/ADC1_IN4: C24.1, R25.2, R26.2, R27.1, U2.17
/MCU/ADC1_IN6: C9.1, R7.2, RT1.1, U2.8
/MCU/ADC1_IN12: C16.1, R17.2, R18.1, U2.25
/MCU/ADC1_IN15: C14.1, R13.2, R14.1, U2.24
/MCU/ADC2_IN5: C27.1, R54.2, TP3.1, U2.22
/MCU/ADC12_IN1: C15.1, R15.2, U2.12
/MCU/ADC12_IN2: C26.1, R44.2, TP2.1, U2.13
/MCU/COMP3_INP: C45.1, R49.1, R50.2, U2.9
/MCU/DAC1: U2.18, U3.4
/MCU/DAC2: R33.1, R38.2, U2.20
/MCU/GPIOB_15: R57.1, U2.37
/MCU/GPIOD_PD2: J7.10, U2.55
/MCU/I2C1_SCL: J7.5, R20.1, U2.51
/MCU/I2C1_SDA: J7.6, R21.1, U2.60
/MCU/I2C3_SCL: R31.1, U2.40, U6.1
/MCU/I2C3_SDA: R32.1, U2.41, U6.3
/MCU/LED_PWR: R42.2, U2.4
/MCU/OSC_IN: U2.5, Y1.3
/MCU/OSC_OUT: U2.6, Y1.1
/MCU/TEMP_BAT: C36.1, J5.1, R39.2, U2.33
/MCU/USART3_RX: J7.4, U2.53
/MCU/USART3_TX: J7.3, U2.52
/MCU/USB_DM: J8.2, U2.45
/MCU/USB_DP: J8.3, U2.46
/MCU/~RESET: C29.1, SWD1.5, U2.7
/PWM_SW-: J4.2, Q5.2, R25.1, R28.2, R29.2, RV1.2
/Power Supply/SMPS_SUPPLY: C18.1, C40.1, D10.1, L2.1, Q9.3, R64.2, T10.3
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C12.2, C13.1, C14.2, C15.2, C16.2, C18.2, C19.2, C21.2, C22.2, C23.2, C24.2, C25.2, C26.2, C27.2, C28.2, C29.2, C30.2, C31.2, C32.2, C33.2, C34.2, C36.2, C39.2, C40.2, C41.2, C42.2, C43.2, C44.1, C45.2, C46.2, C47.2, C48.2, C49.2, D1.2, D5.2, D9.2, J2.2, J5.2, J6.2, J7.2, J8.5, J9.2, J10.8, J10.15, J11.1, LED1.1, Q2.3, Q8.3, R10.1, R12.1, R14.2, R18.2, R22.2, R24.2, R27.2, R34.2, R35.2, R50.1, R51.2, R55.2, R56.2, R62.2, RT1.2, SWD1.3, T4.2, T5.2, T7.2, T9.3, U1.4, U2.15, U2.27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
unnamed: C6.1, R4.1
unnamed: C7.1, J8.6
unnamed: C10.1, R5.2
unnamed: C11.1, R8.2, U3.14
unnamed: C11.2, R9.2, U3.13
unnamed: C19.1, L2.2, U4.4, U4.5
unnamed: C20.1, U4.1
unnamed: C20.2, D1.1, L3.1, U4.6
unnamed: C38.1, D4.3
unnamed: D2.2, Q5.3, Q6.3, R37.2, T1.2
unnamed: D3.1, Q7.1, R58.2, R59.2, R61.1
unnamed: D5.1, R64.1, T10.1
unnamed: D6.2, F2.1
unnamed: D7.1, Q8.1, R56.1
unnamed: D9.1, R60.1, T2.1
unnamed: D11.2, Q9.1, R65.1, R66.2
unnamed: D14.2, Q1.1, R1.1
unnamed: D15.2, Q2.1, R2.1
unnamed: D16.1, R5.1, U1.8
unnamed: D16.2, R3.1
unnamed: F2.2, J8.1
unnamed: J8.4, R22.1
unnamed: LED1.2, R42.1
unnamed: Q3.1, R63.1
unnamed: Q4.1, R67.1
unnamed: R10.2, U3.3
unnamed: R11.1, U3.10
unnamed: R12.2, U3.9
unnamed: R15.1, U3.2
unnamed: R23.2, R24.1, U4.3
unnamed: R29.1, T1.1
unnamed: R30.1, R33.2, U5.3
unnamed: R34.1, R36.1, U5.2
unnamed: R35.1, R38.1, U5.5
unnamed: R36.2, R44.1, R49.2, U5.1
unnamed: R43.1, R47.1, U5.6
unnamed: R46.2, T3.2
unnamed: R47.2, R54.1, U5.7
unnamed: R48.1, R53.2, T3.1
unnamed: R52.1, R55.1, T4.1
unnamed: R53.1, T4.3
unnamed: R57.2, T5.1
unnamed: R59.1, T5.3
unnamed: R66.1, T2.3
unnamed: R81.1, R85.1, T7.3
unnamed: R83.1, T7.1
unnamed: R85.2, T8.1, T9.1
VBUS: C5.1, C35.2, C44.2, D10.2, F1.1, J4.1, J6.1, J10.7, Q7.2, R6.1, R9.1, R17.1, R28.1, R81.2, RV1.1, T2.2, T8.3
VDDA: C34.1, C39.1, R40.1, U2.29
VREF: C48.1, C49.1, R26.1, U2.28

## KiCad design projects/libresolar_mppt_2420_lc_mppt_charger_20a/current_version/working/working.kicad_pcb

File projects/libresolar_mppt_2420_lc_mppt_charger_20a/current_version/working/readme.md:

# mppt_2420_lc
 
## summary 
* id: libresolar_mppt_2420_lc_mppt_charger_20a
* user: libresolar
* name: mppt_2420_lc
* board: mppt_charger_20a
* repo: https://github.com/LibreSolar/mppt-2420-lc
* src_file_repo_kicad_pcb: MPPT_charger_20A.kicad_pcb
* src_file_repo_kicad_pcb_link: https://github.com/LibreSolar/mppt-2420-lc/tree/master/MPPT_charger_20A.kicad_pcb

* src_file_repo_sch: 
* src_file_repo_sch_link: https://github.com/LibreSolar/mppt-2420-lc/tree/master/
* full details link: https://github.com/oomlout/oomlout_oomp_project_bot_v_2/tree/main/projects/libresolar_mppt_2420_lc_mppt_charger_20a/current_version/working

Board: 2 copper layers, 114.5 x 60.5 mm, 146 parts (0 on the bottom side), 102 nets.

Parts:
C1, C2: 1000u; CP_Radial_D16.0mm_P7.50mm
C3, C4, C15: 4.7u; C_1210_3225
C5: 820u; CP_Radial_D10.0mm_P5.00mm
C6: 1n; C_0603_1608
C7, C8, C14, C27: 1u; C_0805_2012
C9, C10, C16, C19, C22, C25, C26, C29, C30, C31, C32, C34, C39, C40, C42: 100n; C_0603_1608
C11, C13, C17, C18, C28: 10n; C_0603_1608
C12, C23, C33, C36, C38: 2.2u; C_0603_1608
C20, C21, C24: 10u; C_0805_2012
C35: 100p; C_0603_1608
D1, D9, D10: 1N4148; D_SOD-123
D2: SS16FP; D_PowerDI-123
D3: USBLC6-2SC6Y; SOT-23-6
D4: NUP2105L; SOT-23
D5: SMBJ36A; D_SMB
D6: LM4040CYM3-2.5; SOT-23
D8: MM3Z12VT1G; D_SOD-323
F1: 25A; KEYSTONE-FUSE-3557-2
F2, F3: 200mA; R_1206_3216
J1: SOLAR; Phoenix_Contact_MKDS_5-2-952
J2: LOAD; Phoenix_Contact_MKDS_5-2-952
J3: BAT; Phoenix_Contact_MKDS_5-2-952
J4: UEXT; Box_Header_2x05x2.54mm_Straight
J5: CONN_01X03; Phoenix_Contact_MC_1,5_3-G-3,81
JP1, JP2: RJ45_NS; RJ45_8P8C
JP3: Jumper_NC_Small; PinHeader_1x02_P2.54mm_Horizontal
L1: 22uH; L-FERYSTER-DTMSS-27
L2: 4.7uH; L_0805_2012Metric
L3: 47uH; Bourns_SRN6045TA
L4: 600R; L_0603_1608Metric
LED1: LED_red; LED_0603_1608Metric
LED2: LED_green; LED_0603_1608Metric
LOGO1: LIBRE_SOLAR; LIBRESOLAR_LOGO
LOGO2: OPEN_HARDWARE; OSHW-Logo_5.7x6mm_SilkScreen
MK1, MK2, MK3: Mounting_Hole; MountingHole_3.2mm_M3
P1: CONN_01X02; PinHeader_1x02_P2.54mm_Vertical
P3: USB Micro B; USB_Micro-B_10103594-0001LF
Q1, Q2, Q3, Q4: CSD18540Q5B; 5X6_MOSFET
Q5, Q6, Q7: BSS84; SOT-23
R1, R3, R10: 3.3; R_0805_2012
R2, R39, R40, R50: 1M; R_0603_1608
R4: 2.2; R_1206_3216
R5, R24, R25, R33, R46, R47: 100k; R_0603_1608
R6, R17: 2m; R_Bourns_CRE2512
R7, R8, R11, R12, R13, R18, R19, R20, R31, R32, R34, R35, R38, R41: 2.2k; R_0603_1608
R9, R30, R45, R49: 56k; R_0603_1608
R14, R15, R21, R22: 150k; R_0603_1608
R16, R23, R27, R29, R37, R44, R48: 10k; R_0603_1608
R26: 5.6k; R_0603_1608
R28: 110k; R_0603_1608
R36: 120; R_1206_3216
R42, R43: 330; R_0603_1608
RT1: 10k; R_0603_1608
SW1: SW_PUSH; SW_SPST_EVQP7A
SWD1: ST_Nucleo_SWD; PinHeader_1x06_P2.54mm_Vertical
T1, T2, T3, T4: MMBT3904; SOT-23
U1: LM5107; SOIC-8_3.9x4.9mm_Pitch1.27mm
U2: STM32F072CB; LQFP-48_7x7mm_P0.5mm
U3: AZ1117; SOT-223-3_TabPin2
U4: MP2459; SOT-23-6
U5: AP2210-3.3; SOT-23-5
U6: 24AA01; SOT-23-5
U7: LM258; SOIC-8_3.9x4.9mm_Pitch1.27mm
U8: TJA1042T/3; SOIC-8_3.9x4.9mm_Pitch1.27mm
Y1: 8MHz; Resonator_Murata_CSTCE_G

Connections:
+3V3: C22.1, C30.1, C31.1, C32.1, C33.1, C38.1, C39.1, L4.1, Q6.2, R5.1, R23.1, R31.2, R32.2, R34.2, R35.2, R37.2, R39.2, R40.2, R44.1, SWD1.1, U2.1, U2.24, U2.36, U2.48, U5.5, U6.4, U8.5
+5V: C9.1, C23.1, C24.1, C26.1, F2.1, Q5.2, R33.1, U3.2, U5.1, U5.3, U7.8, U8.3
+10V: C12.1, C20.1, C21.1, L3.2, R9.2, R28.1, U1.1, U3.3
/Analog Frontend/TEMP_BAT: C40.1, J5.1, R44.2, U2.10
/Analog Frontend/TEMP_INT: C16.1, R23.2, RT1.1, U2.11
/Communication Interfaces/5V_OUT: J5.3, Q5.3
/Communication Interfaces/5V_OUT_EN: R47.2, U2.25
/Communication Interfaces/CAN_GND: D10.2, JP1.3, JP1.7, JP2.3, JP2.7
/Communication Interfaces/CAN_H: D4.1, JP1.1, JP2.1, JP3.1, U8.7
/Communication Interfaces/CAN_L: D4.2, JP1.2, JP2.2, R36.2, U8.6
/Communication Interfaces/CAN_RX: U2.45, U8.4
/Communication Interfaces/CAN_SHLD: JP1.6, JP2.6
/Communication Interfaces/CAN_STB: U2.38, U8.8
/Communication Interfaces/CAN_TX: U2.46, U8.1
/Communication Interfaces/CAN_V+: D9.1, JP1.8, JP2.8
/Communication Interfaces/RJ45_4: JP1.4, JP2.4
/Communication Interfaces/RJ45_5: JP1.5, JP2.5
/Communication Interfaces/UEXT_EN: Q6.1, R5.2, U2.3
/Communication Interfaces/UEXT_RX: J4.4, U2.13
/Communication Interfaces/UEXT_TX: J4.3, U2.12
/Communication Interfaces/USB_DM: D3.3, U2.32
/Communication Interfaces/USB_DP: D3.1, U2.33
/Communication Interfaces/V_BUS_EN: R48.2, U2.4
/DCDC power stage/BAT+: C7.1, F1.2, J3.2
/DCDC power stage/BAT-: C7.2, J3.1, R6.2, R7.2, R17.1, R19.2
/DCDC power stage/DCDC_IN: C1.1, C2.1, C3.1, C4.1, C8.1, C14.1, J1.2, L2.1, Q1.D, R24.1
/DCDC power stage/HS_DRV: R1.2, U1.7
/DCDC power stage/LOAD-: C27.2, C28.2, D5.2, J2.2, Q3.D
/DCDC power stage/LOAD-SW: Q3.S, R8.2, R16.1, R17.2, T1.2
/DCDC power stage/LS_DRV: R3.2, U1.5
/DCDC power stage/PWM_HS: U1.2, U2.29
/DCDC power stage/PWM_LS: U1.3, U2.26
/DCDC power stage/SOLAR-: C8.2, J1.1, Q2.D
/DCDC power stage/SW_NODE: C10.2, L1.1, Q1.S, Q4.D, R4.2, U1.6
/DCDC power stage/~LOAD_EN: R13.2, U2.20
/DCDC_OUT: C5.1, C27.1, D5.1, D8.1, F1.1, J2.1, L1.2, Q7.2, R25.1, R49.1
/MCU/BOOT0: C36.1, R39.1, R41.2, U2.44
/MCU/DAC: C42.1, R14.1, R21.2, U2.14
/MCU/I2C1_SCL: J4.5, R35.1, U2.42
/MCU/I2C1_SDA: J4.6, R34.1, U2.43
/MCU/I2C2_SCL: R31.1, U2.21, U6.1
/MCU/I2C2_SDA: R32.1, U2.22, U6.3
/MCU/I_DCDC: C13.1, R20.2, U2.19
/MCU/I_LOAD: C11.1, R11.2, U2.18
/MCU/LED1: R42.2, U2.27
/MCU/LED2: R43.2, U2.28
/MCU/OSC_IN: U2.5, Y1.1
/MCU/OSC_OUT: U2.6, Y1.3
/MCU/SPI1_MISO: J4.7, U2.40
/MCU/SPI1_MOSI: J4.8, U2.41
/MCU/SPI1_SCK: J4.9, U2.39
/MCU/SSEL: J4.10, U2.2
/MCU/SWCLK: SWD1.2, U2.37
/MCU/SWDIO: SWD1.4, U2.34
/MCU/USART1_RX: P1.2, U2.31
/MCU/USART1_TX: P1.1, U2.30
/MCU/V_BAT: C18.1, R25.2, R27.1, U2.16
/MCU/V_REF: D6.1, R37.1, U2.15
/MCU/V_SOLAR: C17.1, R24.2, R26.1, U2.17
/MCU/~RESET: C29.1, R40.1, R45.1, SW1.1, SWD1.5, U2.7
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C9.2, C11.2, C12.2, C13.2, C14.2, C15.2, C16.2, C17.2, C18.2, C20.2, C21.2, C22.2, C23.2, C24.2, C25.2, C26.2, C29.2, C30.2, C31.2, C32.2, C33.2, C34.2, C35.2, C36.2, C38.2, C39.2, C40.2, C42.2, D2.2, D3.2, D4.3, D6.2, D10.1, J4.2, J5.2, LED1.1, LED2.1, P3.5, Q2.S, Q4.S, R2.1, R6.1, R18.2, R26.2, R27.2, R29.2, R46.2, RT1.2, SW1.2, SWD1.3, T2.2, T3.2, T4.2, U1.4, U2.8, U2.23, U2.35, U2.47, U3.1, U4.2, U5.2, U6.2, U6.5, U7.4, U8.2, Y1.2
unnamed: C6.1, R4.1
unnamed: C10.1, R10.1
unnamed: C15.1, L2.2, R50.2, U4.5
unnamed: C19.1, U4.1
unnamed: C19.2, D2.1, L3.1, U4.6
unnamed: C25.1, P3.6
unnamed: C28.1, Q3.G, R12.1
unnamed: C34.1, L4.2, U2.9
unnamed: C35.1, U5.4
unnamed: D1.1, Q2.G, R2.2
unnamed: D1.2, Q4.G, R3.1
unnamed: D3.4, P3.2
unnamed: D3.5, F2.2, P3.1
unnamed: D3.6, P3.3
unnamed: D8.2, Q7.1, R30.1, R49.2
unnamed: D9.2, F3.1
unnamed: F3.2, Q7.3
unnamed: J4.1, Q6.3
unnamed: JP3.2, R36.1
unnamed: LED1.2, R42.1
unnamed: LED2.2, R43.1
unnamed: P3.4, R46.1
unnamed: Q1.G, R1.1
unnamed: Q5.1, R33.2, R38.1
unnamed: R10.2, U1.8
unnamed: R11.1, R15.2, U7.7
unnamed: R9.1, R12.2, T1.3
unnamed: R13.1, R16.2, T1.1
unnamed: R8.1, R14.2, U7.5
unnamed: R7.1, R15.1, U7.6
unnamed: R18.1, R22.1, U7.2
unnamed: R19.1, R21.1, U7.3
unnamed: R20.1, R22.2, U7.1
unnamed: R28.2, R29.1, U4.3
unnamed: R30.2, T3.3
unnamed: R38.2, T4.3
unnamed: R41.1, T2.3
unnamed: R45.2, T2.1
unnamed: R47.1, T4.1
unnamed: R48.1, T3.1
unnamed: R50.1, U4.4
