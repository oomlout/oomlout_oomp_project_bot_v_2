# Repository oomlout/oomlout_oomp_project_bot_v_2

## KiCad design projects/opulo-inc_lumenpnp_archive_ftp/current_version/working/working.kicad_pcb

File projects/opulo-inc_lumenpnp_archive_ftp/current_version/working/readme.md:

# lumenpnp_archive
 
## summary 
* id: opulo-inc_lumenpnp_archive_ftp
* user: opulo-inc
* name: lumenpnp_archive
* board: ftp
* repo: https://github.com/opulo-inc/lumenpnp-archive
* src_file_repo_kicad_pcb: pnp/pcb/ftp/ftp.kicad_pcb
* src_file_repo_kicad_pcb_link: https://github.com/opulo-inc/lumenpnp-archive/tree/master/pnp/pcb/ftp/ftp.kicad_pcb
* src_file_repo_kicad_sch: pnp/pcb/ftp/ftp.kicad_sch
* src_file_repo_kicad_sch_link: https://github.com/opulo-inc/lumenpnp-archive/tree/master/pnp/pcb/ftp/ftp.kicad_sch

* src_file_repo_sch: 
* src_file_repo_sch_link: https://github.com/opulo-inc/lumenpnp-archive/tree/master/
* full details link: https://github.com/oomlout/oomlout_oomp_project_bot_v_2/tree/main/projects/opulo-inc_lumenpnp_archive_ftp/current_version/working  

## schematic  
  
[schematic (pdf)](working_schematic.pdf) 

## pcb  

[board (pdf)](working.pdf)  

## working_bom
| Id | Designator | Footprint | Quantity | Designation | Supplier and ref |  | None | 
| --- | --- | --- | --- | --- | --- | --- | --- | 
| 1 | D34,D28,D2,D11,D8,D36,D15,D16,D31,D19,D6,D25,D30,D22,D21,D32,D20,D17,D26,D3,D23,D35,D10,D29,D24,D7,D18,D14,D5,D12,D39,D37,D4,D40,D1,D13,D38,D33,D27,D9 | LED_0603_1608Metric | 40 | LED_Small |  |  | [''] | 
| 2 | R16,R29,R2,R15,R24,R3,R11,R33,R18,R32,R12,R5,R13,R6,R23,R37,R9,R38,R25,R10,R4,R14,R1,R21,R36,R28,R19,R17,R39,R22,R8,R7,R35,R27,R20,R26,R34,R31,R30,R40 | R_0603_1608Metric | 40 | R_Small |  |  | [''] | 
| 3 | J1 | PinHeader_1x02_P2.54mm_Vertical | 1 | Conn_01x02_Male |  |  | [''] | 
| 4 | FID3,FID1,FID2 | Fiducial_1mm_Mask3mm | 3 | Fiducial |  |  | [''] | 
| 5 | G*** | cal-dot-grid | 1 | LOGO |  |  | [''] | 

## bom_schematic
| Ref | Qnty | Value | Cmp name | Footprint | Description | Vendor | DNP | 
| --- | --- | --- | --- | --- | --- | --- | --- | 
| D1, D2, D3, D4, D5, D6, D7, D8, D9, D10, D11, D12, D13, D14, D15, D16, D17, D18, D19, D20, D21, D22, D23, D24, D25, D26, D27, D28, D29, D30, D31, D32, D33, D34, D35, D36, D37, D38, D39, D40 | 40 | LED_Small | LED_Small | LED_SMD:LED_0603_1608Metric | Light emitting diode, small symbol |  |  | 
| FID1, FID2, FID3 | 3 | Fiducial | Fiducial | Fiducial:Fiducial_1mm_Mask3mm | Fiducial Marker |  |  | 
| J1 | 1 | Conn_01x02_Male | Conn_01x02_Male | Connector_PinHeader_2.54mm:PinHeader_1x02_P2.54mm_Vertical | Generic connector, single row, 01x02, script generated (kicad-library-utils/schlib/autogen/connector/) |  |  | 
| R1, R2, R3, R4, R5, R6, R7, R8, R9, R10, R11, R12, R13, R14, R15, R16, R17, R18, R19, R20, R21, R22, R23, R24, R25, R26, R27, R28, R29, R30, R31, R32, R33, R34, R35, R36, R37, R38, R39, R40 | 40 | R_Small | R_Small | Resistor_SMD:R_0603_1608Metric | Resistor, small symbol |  |  |

Board: 2 copper layers, 75.0 x 75.0 mm, 84 parts (0 on the bottom side), 42 nets.

Parts:
D1, D2, D3, D4, D5, D6, D7, D8, D9, D10, D11, D12, D13, D14, D15, D16, D17, D18, D19, D20, D21, D22, D23, D24, D25, D26, D27, D28, D29, D30, D31, D32, D33, D34, D35, D36, D37, D38, D39, D40: LED_Small; LED_0603_1608Metric
FID1, FID2, FID3: Fiducial; Fiducial_1mm_Mask3mm
J1: Conn_01x02_Male; PinHeader_1x02_P2.54mm_Vertical
R1, R2, R3, R4, R5, R6, R7, R8, R9, R10, R11, R12, R13, R14, R15, R16, R17, R18, R19, R20, R21, R22, R23, R24, R25, R26, R27, R28, R29, R30, R31, R32, R33, R34, R35, R36, R37, R38, R39, R40: R_Small; R_0603_1608Metric

Connections:
GND: D1.1 (K), D2.1 (K), D3.1 (K), D4.1 (K), D5.1 (K), D6.1 (K), D7.1 (K), D8.1 (K), D9.1 (K), D10.1 (K), D11.1 (K), D12.1 (K), D13.1 (K), D14.1 (K), D15.1 (K), D16.1 (K), D17.1 (K), D18.1 (K), D19.1 (K), D20.1 (K), D21.1 (K), D22.1 (K), D23.1 (K), D24.1 (K), D25.1 (K), D26.1 (K), D27.1 (K), D28.1 (K), D29.1 (K), D30.1 (K), D31.1 (K), D32.1 (K), D33.1 (K), D34.1 (K), D35.1 (K), D36.1 (K), D37.1 (K), D38.1 (K), D39.1 (K), D40.1 (K), J1.2
unnamed: D1.2 (A), R1.2
unnamed: D2.2 (A), R2.2
unnamed: D3.2 (A), R3.2
unnamed: D4.2 (A), R4.2
unnamed: D5.2 (A), R5.2
unnamed: D6.2 (A), R6.2
unnamed: D7.2 (A), R7.2
unnamed: D8.2 (A), R8.2
unnamed: D9.2 (A), R9.2
unnamed: D10.2 (A), R10.2
unnamed: D11.2 (A), R11.2
unnamed: D12.2 (A), R12.2
unnamed: D13.2 (A), R13.2
unnamed: D14.2 (A), R14.2
unnamed: D15.2 (A), R15.2
unnamed: D16.2 (A), R16.2
unnamed: D17.2 (A), R17.2
unnamed: D18.2 (A), R18.2
unnamed: D19.2 (A), R19.2
unnamed: D20.2 (A), R20.2
unnamed: D21.2 (A), R21.2
unnamed: D22.2 (A), R22.2
unnamed: D23.2 (A), R23.2
unnamed: D24.2 (A), R24.2
unnamed: D25.2 (A), R25.2
unnamed: D26.2 (A), R26.2
unnamed: D27.2 (A), R27.2
unnamed: D28.2 (A), R28.2
unnamed: D29.2 (A), R29.2
unnamed: D30.2 (A), R30.2
unnamed: D31.2 (A), R31.2
unnamed: D32.2 (A), R32.2
unnamed: D33.2 (A), R33.2
unnamed: D34.2 (A), R34.2
unnamed: D35.2 (A), R35.2
unnamed: D36.2 (A), R36.2
unnamed: D37.2 (A), R37.2
unnamed: D38.2 (A), R38.2
unnamed: D39.2 (A), R39.2
unnamed: D40.2 (A), R40.2
VDD: J1.1, R1.1, R2.1, R3.1, R4.1, R5.1, R6.1, R7.1, R8.1, R9.1, R10.1, R11.1, R12.1, R13.1, R14.1, R15.1, R16.1, R17.1, R18.1, R19.1, R20.1, R21.1, R22.1, R23.1, R24.1, R25.1, R26.1, R27.1, R28.1, R29.1, R30.1, R31.1, R32.1, R33.1, R34.1, R35.1, R36.1, R37.1, R38.1, R39.1, R40.1

File projects/opulo-inc_lumenpnp_archive_ftp/current_version/working/working_bom_schematic.csv:

"Source:","C:\gh\oomlout_oomp_project_bot_v_2\projects\opulo-inc_lumenpnp_archive_ftp\current_version\working\working.kicad_sch"
"Date:","12/09/2023 04:46:02"
"Tool:","Eeschema 7.0.6"
"Generator:","C:/Program Files/KiCad/7.0/bin/scripting/plugins/bom_csv_grouped_by_value_with_fp.py"
"Component Count:","84"
"Ref","Qnty","Value","Cmp name","Footprint","Description","Vendor","DNP"
"D1, D2, D3, D4, D5, D6, D7, D8, D9, D10, D11, D12, D13, D14, D15, D16, D17, D18, D19, D20, D21, D22, D23, D24, D25, D26, D27, D28, D29, D30, D31, D32, D33, D34, D35, D36, D37, D38, D39, D40","40","LED_Small","LED_Small","LED_SMD:LED_0603_1608Metric","Light emitting diode, small symbol","",""
"FID1, FID2, FID3","3","Fiducial","Fiducial","Fiducial:Fiducial_1mm_Mask3mm","Fiducial Marker","",""
"J1","1","Conn_01x02_Male","Conn_01x02_Male","Connector_PinHeader_2.54mm:PinHeader_1x02_P2.54mm_Vertical","Generic connector, single row, 01x02, script generated (kicad-library-utils/schlib/autogen/connector/)","",""
"R1, R2, R3, R4, R5, R6, R7, R8, R9, R10, R11, R12, R13, R14, R15, R16, R17, R18, R19, R20, R21, R22, R23, R24, R25, R26, R27, R28, R29, R30, R31, R32, R33, R34, R35, R36, R37, R38, R39, R40","40","R_Small","R_Small","Resistor_SMD:R_0603_1608Metric","Resistor, small symbol","",""

## KiCad design projects/opulo_inc_feeder_feederfloor/current_version/working/working.kicad_pcb

File projects/opulo_inc_feeder_feederfloor/current_version/working/readme.md:

# feeder
 
## summary 
* id: opulo_inc_feeder_feederfloor
* user: opulo_inc
* name: feeder
* board: feederfloor
* repo: https://github.com/opulo-inc/feeder
* src_file_repo_kicad_pcb: pcb/feederFloor/feederFloor.kicad_pcb
* src_file_repo_kicad_pcb_link: https://github.com/opulo-inc/feeder/tree/main/pcb/feederFloor/feederFloor.kicad_pcb
* src_file_repo_kicad_sch: pcb/feederFloor/feederFloor.kicad_sch
* src_file_repo_kicad_sch_link: https://github.com/opulo-inc/feeder/tree/main/pcb/feederFloor/feederFloor.kicad_sch

* src_file_repo_sch: 
* src_file_repo_sch_link: https://github.com/opulo-inc/feeder/tree/main/
* full details link: https://github.com/oomlout/oomlout_oomp_project_bot_v_2/tree/main/projects/opulo_inc_feeder_feederfloor/current_version/working

Board: 2 copper layers, 13.4 x 31.1 mm, 6 parts (1 on the bottom side), 5 nets.

Parts:
H1: MountingHole; MountingHole_3.2mm_M3
J1: IDC; PinHeader_2x03_P2.54mm_Vertical
J2: Conn_01x05_Female; AVX-915-005-541-Contact-Surface
R1: 120R; R_0805_2012Metric
R2: 1M; R_0805_2012Metric
U1: DS28E07; DS28E07_MULTI

Connections:
1WIRE: J2.1, R2.1, U1.2 (IO)
GND: J1.1, J1.2, J2.4, R2.2, U1.1 (GND)
RS-485+: J1.5, J2.2, R1.2
RS-485-: J1.6, J2.3, R1.1
VIN: J1.3, J1.4, J2.5

## KiCad design projects/opulo_inc_lumenpnp_archive_ringlight/current_version/working/working.kicad_pcb

File projects/opulo_inc_lumenpnp_archive_ringlight/current_version/working/readme.md:

# lumenpnp_archive
 
## summary 
* id: opulo_inc_lumenpnp_archive_ringlight
* user: opulo_inc
* name: lumenpnp_archive
* board: ringlight
* repo: https://github.com/opulo-inc/lumenpnp-archive
* src_file_repo_kicad_pcb: pnp/pcb/ring-light/ringLight.kicad_pcb
* src_file_repo_kicad_pcb_link: https://github.com/opulo-inc/lumenpnp-archive/tree/master/pnp/pcb/ring-light/ringLight.kicad_pcb
* src_file_repo_kicad_sch: pnp/pcb/ring-light/ringLight.kicad_sch
* src_file_repo_kicad_sch_link: https://github.com/opulo-inc/lumenpnp-archive/tree/master/pnp/pcb/ring-light/ringLight.kicad_sch

* src_file_repo_sch: 
* src_file_repo_sch_link: https://github.com/opulo-inc/lumenpnp-archive/tree/master/
* full details link: https://github.com/oomlout/oomlout_oomp_project_bot_v_2/tree/main/projects/opulo_inc_lumenpnp_archive_ringlight/current_version/working

Board: 2 copper layers, 40.0 x 50.2 mm, 36 parts (8 on the bottom side), 12 nets.

Parts:
C1, C2, C3, C4, C5, C6, C7, C9, C10: 100nF; C_0805_2012Metric
D1, D2, D3, D4, D5, D6, D7, D8: WS2812B; LED_WS2812B_PLCC4_5.0x5.0mm_P3.2mm
FID1, FID2, FID3: Fiducial; Fiducial_1mm_Mask2mm
J1: Connector Vertical; JST_XH_B3B-XH-A_1x03_P2.50mm_Vertical
J2: Connector Horizontal; JST_XH_S3B-XH-A-1_1x03_P2.50mm_Horizontal
LOGO: LOGO; logo
R1: 330R; R_0805_2012Metric
U1: 74AHCT1G32; SOT-353_SC-70-5
kibuzzard-61F2BC8D, kibuzzard-61F2BC8D#2: G***; kibuzzard-61F2BC8D
kibuzzard-61F2BC9E, kibuzzard-61F2BC9E#2: G***; kibuzzard-61F2BC9E
kibuzzard-61F2BC96, kibuzzard-61F2BC96#2: G***; kibuzzard-61F2BC96
kibuzzard-61F2BEFE: G***; kibuzzard-61F2BEFE
kibuzzard-61F2BF3C: G***; kibuzzard-61F2BF3C
kibuzzard-61F2BF4A: G***; kibuzzard-61F2BF4A
kibuzzard-61F2BF10: G***; kibuzzard-61F2BF10
svg2mod: n/a; label

Connections:
+5V: C1.1, C2.1, C3.1, C4.1, C5.1, C6.1, C7.1, C9.1, C10.1, D1.1 (VDD), D2.1 (VDD), D3.1 (VDD), D4.1 (VDD), D5.1 (VDD), D6.1 (VDD), D7.1 (VDD), D8.1 (VDD), J1.2, J2.2, U1.5 (VCC)
Data_In_3V3: J1.1, J2.1, R1.2
Data_In_5V: D1.4 (DIN), U1.4
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C9.2, C10.2, D1.3 (VSS), D2.3 (VSS), D3.3 (VSS), D4.3 (VSS), D5.3 (VSS), D6.3 (VSS), D7.3 (VSS), D8.3 (VSS), J1.3, J2.3, U1.1, U1.3 (GND)
unnamed: D1.2 (DOUT), D2.4 (DIN)
unnamed: D2.2 (DOUT), D3.4 (DIN)
unnamed: D3.2 (DOUT), D4.4 (DIN)
unnamed: D4.2 (DOUT), D5.4 (DIN)
unnamed: D5.2 (DOUT), D6.4 (DIN)
unnamed: D6.2 (DOUT), D7.4 (DIN)
unnamed: D7.2 (DOUT), D8.4 (DIN)
unnamed: R1.1, U1.2
